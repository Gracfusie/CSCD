*
* Copyright 2018 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.3g
* Version: 2006Q4V1
* Name: High Speed/Density Single Port SRAM Generator|CL018HV Process
* Comment:
* Configuration:  -instname "RA1SHD_2048x32M8" -words 2048 -bits 32\
* Configuration:  -frequency 100 -ring_width 2 -mux 8 -drive 12 -wr\
* Configuration: ite_mask on -wp_size 8 -top_layer met5 -power_type\
* Configuration:  rings -horiz met4 -vert met3 -cust_comment "" -le\
* Configuration: ft_bus_delim "[" -right_bus_delim "]" -pwr_gnd_ren\
* Configuration: ame "VDD:VDD,VSS:VSS" -prefix "" -pin_space 0.0 -n\
* Configuration: ame_case upper -check_instname on -diodes on -insi\
* Configuration: de_ring_type GND -asvm off
* Codefile:
*
*
** begin lvs.header
** $Revision: 1.2 $
*.SCALE meter
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RA1SHD_2048x32M8CCG BL BL_ WL WP VSS VDD
** RA1SHD_2048x32M8CCG: 6 flat devices **
m1 BL WP CORED VSS N L=0.265U W=0.22U AD=0.1272P PD=1.225U AS=0.1272P
+  PS=1.225U
m2 BL_ WP CORED_ VSS N L=0.265U W=0.22U AD=0.1272P PD=1.225U AS=0.1272P
+  PS=1.225U
m3 CORED_ CORED VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
m5 CORED CORED_ VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
.ENDS RA1SHD_2048x32M8CCG
****
.SUBCKT RA1SHD_2048x32M8FCR WLB WLT VSS VDD
** RA1SHD_2048x32M8FCR: 4 flat devices **
MM1 NWT1 WLB VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM2 NWT2 WLT VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM3 NWT3 WLB VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM4 NWT4 WLT VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
.ENDS RA1SHD_2048x32M8FCR
****
.SUBCKT RA1SHD_2048x32M8FCIO8 GTP OE_ WE VSS VDD
** RA1SHD_2048x32M8FCIO8: 3 flat devices **
d1 VSS GTP DN 0.2304P 2.32U
d2 VSS OE_ DN 0.2304P 2.32U
d3 VSS WE DN 0.2304P 2.32U
.ENDS RA1SHD_2048x32M8FCIO8
****
.SUBCKT RA1SHD_2048x32M8FCSA8 GTP VSS VDD
** RA1SHD_2048x32M8FCSA8: 1 flat devices **
d1 VSS GTP DN 0.2304P 2.32U
.ENDS RA1SHD_2048x32M8FCSA8
****
.SUBCKT RA1SHD_2048x32M8FCCDL A0 A0_ DR DR_ DW DW_ GTP VD YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8FCCDL: 1 flat devices **
m1 VDD VSS VD VDD P L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
.ENDS RA1SHD_2048x32M8FCCDL
****
.SUBCKT RA1SHD_2048x32M8FCUR VSS VDD
** RA1SHD_2048x32M8FCUR: 4 flat devices **
MM1 NWT1 VSS VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM2 NWT2 VSS VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM3 NWT3 VSS VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM4 NWT4 VSS VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
.ENDS RA1SHD_2048x32M8FCUR
****
.SUBCKT RA1SHD_2048x32M8LEFT_CAP A0 A0_ DR DR_ DW DW_ GTP_0 GTP_1 GTP_2 OE_ WE
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8LEFT_CAP: 2069 flat devices **
XI0_0 GTP_0 OE_ WE VSS VDD RA1SHD_2048x32M8FCIO8
XI0_1 GTP_1 VSS VDD RA1SHD_2048x32M8FCSA8
XI0_10 BL BL WL_6 WL_6 VSS VDD RA1SHD_2048x32M8CCG
XI0_100 BL BL WL_96 WL_96 VSS VDD RA1SHD_2048x32M8CCG
XI0_101 BL BL WL_97 WL_97 VSS VDD RA1SHD_2048x32M8CCG
XI0_102 BL BL WL_98 WL_98 VSS VDD RA1SHD_2048x32M8CCG
XI0_103 BL BL WL_99 WL_99 VSS VDD RA1SHD_2048x32M8CCG
XI0_104 BL BL WL_100 WL_100 VSS VDD RA1SHD_2048x32M8CCG
XI0_105 BL BL WL_101 WL_101 VSS VDD RA1SHD_2048x32M8CCG
XI0_106 BL BL WL_102 WL_102 VSS VDD RA1SHD_2048x32M8CCG
XI0_107 BL BL WL_103 WL_103 VSS VDD RA1SHD_2048x32M8CCG
XI0_108 BL BL WL_104 WL_104 VSS VDD RA1SHD_2048x32M8CCG
XI0_109 BL BL WL_105 WL_105 VSS VDD RA1SHD_2048x32M8CCG
XI0_11 BL BL WL_7 WL_7 VSS VDD RA1SHD_2048x32M8CCG
XI0_110 BL BL WL_106 WL_106 VSS VDD RA1SHD_2048x32M8CCG
XI0_111 BL BL WL_107 WL_107 VSS VDD RA1SHD_2048x32M8CCG
XI0_112 BL BL WL_108 WL_108 VSS VDD RA1SHD_2048x32M8CCG
XI0_113 BL BL WL_109 WL_109 VSS VDD RA1SHD_2048x32M8CCG
XI0_114 BL BL WL_110 WL_110 VSS VDD RA1SHD_2048x32M8CCG
XI0_115 BL BL WL_111 WL_111 VSS VDD RA1SHD_2048x32M8CCG
XI0_116 BL BL WL_112 WL_112 VSS VDD RA1SHD_2048x32M8CCG
XI0_117 BL BL WL_113 WL_113 VSS VDD RA1SHD_2048x32M8CCG
XI0_118 BL BL WL_114 WL_114 VSS VDD RA1SHD_2048x32M8CCG
XI0_119 BL BL WL_115 WL_115 VSS VDD RA1SHD_2048x32M8CCG
XI0_12 BL BL WL_8 WL_8 VSS VDD RA1SHD_2048x32M8CCG
XI0_120 BL BL WL_116 WL_116 VSS VDD RA1SHD_2048x32M8CCG
XI0_121 BL BL WL_117 WL_117 VSS VDD RA1SHD_2048x32M8CCG
XI0_122 BL BL WL_118 WL_118 VSS VDD RA1SHD_2048x32M8CCG
XI0_123 BL BL WL_119 WL_119 VSS VDD RA1SHD_2048x32M8CCG
XI0_124 BL BL WL_120 WL_120 VSS VDD RA1SHD_2048x32M8CCG
XI0_125 BL BL WL_121 WL_121 VSS VDD RA1SHD_2048x32M8CCG
XI0_126 BL BL WL_122 WL_122 VSS VDD RA1SHD_2048x32M8CCG
XI0_127 BL BL WL_123 WL_123 VSS VDD RA1SHD_2048x32M8CCG
XI0_128 BL BL WL_124 WL_124 VSS VDD RA1SHD_2048x32M8CCG
XI0_129 BL BL WL_125 WL_125 VSS VDD RA1SHD_2048x32M8CCG
XI0_13 BL BL WL_9 WL_9 VSS VDD RA1SHD_2048x32M8CCG
XI0_130 BL BL WL_126 WL_126 VSS VDD RA1SHD_2048x32M8CCG
XI0_131 BL BL WL_127 WL_127 VSS VDD RA1SHD_2048x32M8CCG
XI0_132 BL BL WL_128 WL_128 VSS VDD RA1SHD_2048x32M8CCG
XI0_133 BL BL WL_129 WL_129 VSS VDD RA1SHD_2048x32M8CCG
XI0_134 BL BL WL_130 WL_130 VSS VDD RA1SHD_2048x32M8CCG
XI0_135 BL BL WL_131 WL_131 VSS VDD RA1SHD_2048x32M8CCG
XI0_136 BL BL WL_132 WL_132 VSS VDD RA1SHD_2048x32M8CCG
XI0_137 BL BL WL_133 WL_133 VSS VDD RA1SHD_2048x32M8CCG
XI0_138 BL BL WL_134 WL_134 VSS VDD RA1SHD_2048x32M8CCG
XI0_139 BL BL WL_135 WL_135 VSS VDD RA1SHD_2048x32M8CCG
XI0_14 BL BL WL_10 WL_10 VSS VDD RA1SHD_2048x32M8CCG
XI0_140 BL BL WL_136 WL_136 VSS VDD RA1SHD_2048x32M8CCG
XI0_141 BL BL WL_137 WL_137 VSS VDD RA1SHD_2048x32M8CCG
XI0_142 BL BL WL_138 WL_138 VSS VDD RA1SHD_2048x32M8CCG
XI0_143 BL BL WL_139 WL_139 VSS VDD RA1SHD_2048x32M8CCG
XI0_144 BL BL WL_140 WL_140 VSS VDD RA1SHD_2048x32M8CCG
XI0_145 BL BL WL_141 WL_141 VSS VDD RA1SHD_2048x32M8CCG
XI0_146 BL BL WL_142 WL_142 VSS VDD RA1SHD_2048x32M8CCG
XI0_147 BL BL WL_143 WL_143 VSS VDD RA1SHD_2048x32M8CCG
XI0_148 BL BL WL_144 WL_144 VSS VDD RA1SHD_2048x32M8CCG
XI0_149 BL BL WL_145 WL_145 VSS VDD RA1SHD_2048x32M8CCG
XI0_15 BL BL WL_11 WL_11 VSS VDD RA1SHD_2048x32M8CCG
XI0_150 BL BL WL_146 WL_146 VSS VDD RA1SHD_2048x32M8CCG
XI0_151 BL BL WL_147 WL_147 VSS VDD RA1SHD_2048x32M8CCG
XI0_152 BL BL WL_148 WL_148 VSS VDD RA1SHD_2048x32M8CCG
XI0_153 BL BL WL_149 WL_149 VSS VDD RA1SHD_2048x32M8CCG
XI0_154 BL BL WL_150 WL_150 VSS VDD RA1SHD_2048x32M8CCG
XI0_155 BL BL WL_151 WL_151 VSS VDD RA1SHD_2048x32M8CCG
XI0_156 BL BL WL_152 WL_152 VSS VDD RA1SHD_2048x32M8CCG
XI0_157 BL BL WL_153 WL_153 VSS VDD RA1SHD_2048x32M8CCG
XI0_158 BL BL WL_154 WL_154 VSS VDD RA1SHD_2048x32M8CCG
XI0_159 BL BL WL_155 WL_155 VSS VDD RA1SHD_2048x32M8CCG
XI0_16 BL BL WL_12 WL_12 VSS VDD RA1SHD_2048x32M8CCG
XI0_160 BL BL WL_156 WL_156 VSS VDD RA1SHD_2048x32M8CCG
XI0_161 BL BL WL_157 WL_157 VSS VDD RA1SHD_2048x32M8CCG
XI0_162 BL BL WL_158 WL_158 VSS VDD RA1SHD_2048x32M8CCG
XI0_163 BL BL WL_159 WL_159 VSS VDD RA1SHD_2048x32M8CCG
XI0_164 BL BL WL_160 WL_160 VSS VDD RA1SHD_2048x32M8CCG
XI0_165 BL BL WL_161 WL_161 VSS VDD RA1SHD_2048x32M8CCG
XI0_166 BL BL WL_162 WL_162 VSS VDD RA1SHD_2048x32M8CCG
XI0_167 BL BL WL_163 WL_163 VSS VDD RA1SHD_2048x32M8CCG
XI0_168 BL BL WL_164 WL_164 VSS VDD RA1SHD_2048x32M8CCG
XI0_169 BL BL WL_165 WL_165 VSS VDD RA1SHD_2048x32M8CCG
XI0_17 BL BL WL_13 WL_13 VSS VDD RA1SHD_2048x32M8CCG
XI0_170 BL BL WL_166 WL_166 VSS VDD RA1SHD_2048x32M8CCG
XI0_171 BL BL WL_167 WL_167 VSS VDD RA1SHD_2048x32M8CCG
XI0_172 BL BL WL_168 WL_168 VSS VDD RA1SHD_2048x32M8CCG
XI0_173 BL BL WL_169 WL_169 VSS VDD RA1SHD_2048x32M8CCG
XI0_174 BL BL WL_170 WL_170 VSS VDD RA1SHD_2048x32M8CCG
XI0_175 BL BL WL_171 WL_171 VSS VDD RA1SHD_2048x32M8CCG
XI0_176 BL BL WL_172 WL_172 VSS VDD RA1SHD_2048x32M8CCG
XI0_177 BL BL WL_173 WL_173 VSS VDD RA1SHD_2048x32M8CCG
XI0_178 BL BL WL_174 WL_174 VSS VDD RA1SHD_2048x32M8CCG
XI0_179 BL BL WL_175 WL_175 VSS VDD RA1SHD_2048x32M8CCG
XI0_18 BL BL WL_14 WL_14 VSS VDD RA1SHD_2048x32M8CCG
XI0_180 BL BL WL_176 WL_176 VSS VDD RA1SHD_2048x32M8CCG
XI0_181 BL BL WL_177 WL_177 VSS VDD RA1SHD_2048x32M8CCG
XI0_182 BL BL WL_178 WL_178 VSS VDD RA1SHD_2048x32M8CCG
XI0_183 BL BL WL_179 WL_179 VSS VDD RA1SHD_2048x32M8CCG
XI0_184 BL BL WL_180 WL_180 VSS VDD RA1SHD_2048x32M8CCG
XI0_185 BL BL WL_181 WL_181 VSS VDD RA1SHD_2048x32M8CCG
XI0_186 BL BL WL_182 WL_182 VSS VDD RA1SHD_2048x32M8CCG
XI0_187 BL BL WL_183 WL_183 VSS VDD RA1SHD_2048x32M8CCG
XI0_188 BL BL WL_184 WL_184 VSS VDD RA1SHD_2048x32M8CCG
XI0_189 BL BL WL_185 WL_185 VSS VDD RA1SHD_2048x32M8CCG
XI0_19 BL BL WL_15 WL_15 VSS VDD RA1SHD_2048x32M8CCG
XI0_190 BL BL WL_186 WL_186 VSS VDD RA1SHD_2048x32M8CCG
XI0_191 BL BL WL_187 WL_187 VSS VDD RA1SHD_2048x32M8CCG
XI0_192 BL BL WL_188 WL_188 VSS VDD RA1SHD_2048x32M8CCG
XI0_193 BL BL WL_189 WL_189 VSS VDD RA1SHD_2048x32M8CCG
XI0_194 BL BL WL_190 WL_190 VSS VDD RA1SHD_2048x32M8CCG
XI0_195 BL BL WL_191 WL_191 VSS VDD RA1SHD_2048x32M8CCG
XI0_196 BL BL WL_192 WL_192 VSS VDD RA1SHD_2048x32M8CCG
XI0_197 BL BL WL_193 WL_193 VSS VDD RA1SHD_2048x32M8CCG
XI0_198 BL BL WL_194 WL_194 VSS VDD RA1SHD_2048x32M8CCG
XI0_199 BL BL WL_195 WL_195 VSS VDD RA1SHD_2048x32M8CCG
XI0_2 A0 A0_ DR DR_ DW DW_ GTP_2 BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD_2048x32M8FCCDL
XI0_20 BL BL WL_16 WL_16 VSS VDD RA1SHD_2048x32M8CCG
XI0_200 BL BL WL_196 WL_196 VSS VDD RA1SHD_2048x32M8CCG
XI0_201 BL BL WL_197 WL_197 VSS VDD RA1SHD_2048x32M8CCG
XI0_202 BL BL WL_198 WL_198 VSS VDD RA1SHD_2048x32M8CCG
XI0_203 BL BL WL_199 WL_199 VSS VDD RA1SHD_2048x32M8CCG
XI0_204 BL BL WL_200 WL_200 VSS VDD RA1SHD_2048x32M8CCG
XI0_205 BL BL WL_201 WL_201 VSS VDD RA1SHD_2048x32M8CCG
XI0_206 BL BL WL_202 WL_202 VSS VDD RA1SHD_2048x32M8CCG
XI0_207 BL BL WL_203 WL_203 VSS VDD RA1SHD_2048x32M8CCG
XI0_208 BL BL WL_204 WL_204 VSS VDD RA1SHD_2048x32M8CCG
XI0_209 BL BL WL_205 WL_205 VSS VDD RA1SHD_2048x32M8CCG
XI0_21 BL BL WL_17 WL_17 VSS VDD RA1SHD_2048x32M8CCG
XI0_210 BL BL WL_206 WL_206 VSS VDD RA1SHD_2048x32M8CCG
XI0_211 BL BL WL_207 WL_207 VSS VDD RA1SHD_2048x32M8CCG
XI0_212 BL BL WL_208 WL_208 VSS VDD RA1SHD_2048x32M8CCG
XI0_213 BL BL WL_209 WL_209 VSS VDD RA1SHD_2048x32M8CCG
XI0_214 BL BL WL_210 WL_210 VSS VDD RA1SHD_2048x32M8CCG
XI0_215 BL BL WL_211 WL_211 VSS VDD RA1SHD_2048x32M8CCG
XI0_216 BL BL WL_212 WL_212 VSS VDD RA1SHD_2048x32M8CCG
XI0_217 BL BL WL_213 WL_213 VSS VDD RA1SHD_2048x32M8CCG
XI0_218 BL BL WL_214 WL_214 VSS VDD RA1SHD_2048x32M8CCG
XI0_219 BL BL WL_215 WL_215 VSS VDD RA1SHD_2048x32M8CCG
XI0_22 BL BL WL_18 WL_18 VSS VDD RA1SHD_2048x32M8CCG
XI0_220 BL BL WL_216 WL_216 VSS VDD RA1SHD_2048x32M8CCG
XI0_221 BL BL WL_217 WL_217 VSS VDD RA1SHD_2048x32M8CCG
XI0_222 BL BL WL_218 WL_218 VSS VDD RA1SHD_2048x32M8CCG
XI0_223 BL BL WL_219 WL_219 VSS VDD RA1SHD_2048x32M8CCG
XI0_224 BL BL WL_220 WL_220 VSS VDD RA1SHD_2048x32M8CCG
XI0_225 BL BL WL_221 WL_221 VSS VDD RA1SHD_2048x32M8CCG
XI0_226 BL BL WL_222 WL_222 VSS VDD RA1SHD_2048x32M8CCG
XI0_227 BL BL WL_223 WL_223 VSS VDD RA1SHD_2048x32M8CCG
XI0_228 BL BL WL_224 WL_224 VSS VDD RA1SHD_2048x32M8CCG
XI0_229 BL BL WL_225 WL_225 VSS VDD RA1SHD_2048x32M8CCG
XI0_23 BL BL WL_19 WL_19 VSS VDD RA1SHD_2048x32M8CCG
XI0_230 BL BL WL_226 WL_226 VSS VDD RA1SHD_2048x32M8CCG
XI0_231 BL BL WL_227 WL_227 VSS VDD RA1SHD_2048x32M8CCG
XI0_232 BL BL WL_228 WL_228 VSS VDD RA1SHD_2048x32M8CCG
XI0_233 BL BL WL_229 WL_229 VSS VDD RA1SHD_2048x32M8CCG
XI0_234 BL BL WL_230 WL_230 VSS VDD RA1SHD_2048x32M8CCG
XI0_235 BL BL WL_231 WL_231 VSS VDD RA1SHD_2048x32M8CCG
XI0_236 BL BL WL_232 WL_232 VSS VDD RA1SHD_2048x32M8CCG
XI0_237 BL BL WL_233 WL_233 VSS VDD RA1SHD_2048x32M8CCG
XI0_238 BL BL WL_234 WL_234 VSS VDD RA1SHD_2048x32M8CCG
XI0_239 BL BL WL_235 WL_235 VSS VDD RA1SHD_2048x32M8CCG
XI0_24 BL BL WL_20 WL_20 VSS VDD RA1SHD_2048x32M8CCG
XI0_240 BL BL WL_236 WL_236 VSS VDD RA1SHD_2048x32M8CCG
XI0_241 BL BL WL_237 WL_237 VSS VDD RA1SHD_2048x32M8CCG
XI0_242 BL BL WL_238 WL_238 VSS VDD RA1SHD_2048x32M8CCG
XI0_243 BL BL WL_239 WL_239 VSS VDD RA1SHD_2048x32M8CCG
XI0_244 BL BL WL_240 WL_240 VSS VDD RA1SHD_2048x32M8CCG
XI0_245 BL BL WL_241 WL_241 VSS VDD RA1SHD_2048x32M8CCG
XI0_246 BL BL WL_242 WL_242 VSS VDD RA1SHD_2048x32M8CCG
XI0_247 BL BL WL_243 WL_243 VSS VDD RA1SHD_2048x32M8CCG
XI0_248 BL BL WL_244 WL_244 VSS VDD RA1SHD_2048x32M8CCG
XI0_249 BL BL WL_245 WL_245 VSS VDD RA1SHD_2048x32M8CCG
XI0_25 BL BL WL_21 WL_21 VSS VDD RA1SHD_2048x32M8CCG
XI0_250 BL BL WL_246 WL_246 VSS VDD RA1SHD_2048x32M8CCG
XI0_251 BL BL WL_247 WL_247 VSS VDD RA1SHD_2048x32M8CCG
XI0_252 BL BL WL_248 WL_248 VSS VDD RA1SHD_2048x32M8CCG
XI0_253 BL BL WL_249 WL_249 VSS VDD RA1SHD_2048x32M8CCG
XI0_254 BL BL WL_250 WL_250 VSS VDD RA1SHD_2048x32M8CCG
XI0_255 BL BL WL_251 WL_251 VSS VDD RA1SHD_2048x32M8CCG
XI0_256 BL BL WL_252 WL_252 VSS VDD RA1SHD_2048x32M8CCG
XI0_257 BL BL WL_253 WL_253 VSS VDD RA1SHD_2048x32M8CCG
XI0_258 BL BL WL_254 WL_254 VSS VDD RA1SHD_2048x32M8CCG
XI0_259 BL BL WL_255 WL_255 VSS VDD RA1SHD_2048x32M8CCG
XI0_26 BL BL WL_22 WL_22 VSS VDD RA1SHD_2048x32M8CCG
XI0_260 BL BL VSS VSS VSS VDD RA1SHD_2048x32M8CCG
XI0_261 BL BL VSS VSS VSS VDD RA1SHD_2048x32M8CCG
XI0_27 BL BL WL_23 WL_23 VSS VDD RA1SHD_2048x32M8CCG
XI0_28 BL BL WL_24 WL_24 VSS VDD RA1SHD_2048x32M8CCG
XI0_29 BL BL WL_25 WL_25 VSS VDD RA1SHD_2048x32M8CCG
XI0_30 BL BL WL_26 WL_26 VSS VDD RA1SHD_2048x32M8CCG
XI0_31 BL BL WL_27 WL_27 VSS VDD RA1SHD_2048x32M8CCG
XI0_32 BL BL WL_28 WL_28 VSS VDD RA1SHD_2048x32M8CCG
XI0_33 BL BL WL_29 WL_29 VSS VDD RA1SHD_2048x32M8CCG
XI0_34 BL BL WL_30 WL_30 VSS VDD RA1SHD_2048x32M8CCG
XI0_35 BL BL WL_31 WL_31 VSS VDD RA1SHD_2048x32M8CCG
XI0_36 BL BL WL_32 WL_32 VSS VDD RA1SHD_2048x32M8CCG
XI0_37 BL BL WL_33 WL_33 VSS VDD RA1SHD_2048x32M8CCG
XI0_38 BL BL WL_34 WL_34 VSS VDD RA1SHD_2048x32M8CCG
XI0_39 BL BL WL_35 WL_35 VSS VDD RA1SHD_2048x32M8CCG
XI0_4 BL BL WL_0 WL_0 VSS VDD RA1SHD_2048x32M8CCG
XI0_40 BL BL WL_36 WL_36 VSS VDD RA1SHD_2048x32M8CCG
XI0_41 BL BL WL_37 WL_37 VSS VDD RA1SHD_2048x32M8CCG
XI0_42 BL BL WL_38 WL_38 VSS VDD RA1SHD_2048x32M8CCG
XI0_43 BL BL WL_39 WL_39 VSS VDD RA1SHD_2048x32M8CCG
XI0_44 BL BL WL_40 WL_40 VSS VDD RA1SHD_2048x32M8CCG
XI0_45 BL BL WL_41 WL_41 VSS VDD RA1SHD_2048x32M8CCG
XI0_46 BL BL WL_42 WL_42 VSS VDD RA1SHD_2048x32M8CCG
XI0_47 BL BL WL_43 WL_43 VSS VDD RA1SHD_2048x32M8CCG
XI0_48 BL BL WL_44 WL_44 VSS VDD RA1SHD_2048x32M8CCG
XI0_49 BL BL WL_45 WL_45 VSS VDD RA1SHD_2048x32M8CCG
XI0_5 BL BL WL_1 WL_1 VSS VDD RA1SHD_2048x32M8CCG
XI0_50 BL BL WL_46 WL_46 VSS VDD RA1SHD_2048x32M8CCG
XI0_51 BL BL WL_47 WL_47 VSS VDD RA1SHD_2048x32M8CCG
XI0_52 BL BL WL_48 WL_48 VSS VDD RA1SHD_2048x32M8CCG
XI0_53 BL BL WL_49 WL_49 VSS VDD RA1SHD_2048x32M8CCG
XI0_54 BL BL WL_50 WL_50 VSS VDD RA1SHD_2048x32M8CCG
XI0_55 BL BL WL_51 WL_51 VSS VDD RA1SHD_2048x32M8CCG
XI0_56 BL BL WL_52 WL_52 VSS VDD RA1SHD_2048x32M8CCG
XI0_57 BL BL WL_53 WL_53 VSS VDD RA1SHD_2048x32M8CCG
XI0_58 BL BL WL_54 WL_54 VSS VDD RA1SHD_2048x32M8CCG
XI0_59 BL BL WL_55 WL_55 VSS VDD RA1SHD_2048x32M8CCG
XI0_6 BL BL WL_2 WL_2 VSS VDD RA1SHD_2048x32M8CCG
XI0_60 BL BL WL_56 WL_56 VSS VDD RA1SHD_2048x32M8CCG
XI0_61 BL BL WL_57 WL_57 VSS VDD RA1SHD_2048x32M8CCG
XI0_62 BL BL WL_58 WL_58 VSS VDD RA1SHD_2048x32M8CCG
XI0_63 BL BL WL_59 WL_59 VSS VDD RA1SHD_2048x32M8CCG
XI0_64 BL BL WL_60 WL_60 VSS VDD RA1SHD_2048x32M8CCG
XI0_65 BL BL WL_61 WL_61 VSS VDD RA1SHD_2048x32M8CCG
XI0_66 BL BL WL_62 WL_62 VSS VDD RA1SHD_2048x32M8CCG
XI0_67 BL BL WL_63 WL_63 VSS VDD RA1SHD_2048x32M8CCG
XI0_68 BL BL WL_64 WL_64 VSS VDD RA1SHD_2048x32M8CCG
XI0_69 BL BL WL_65 WL_65 VSS VDD RA1SHD_2048x32M8CCG
XI0_7 BL BL WL_3 WL_3 VSS VDD RA1SHD_2048x32M8CCG
XI0_70 BL BL WL_66 WL_66 VSS VDD RA1SHD_2048x32M8CCG
XI0_71 BL BL WL_67 WL_67 VSS VDD RA1SHD_2048x32M8CCG
XI0_72 BL BL WL_68 WL_68 VSS VDD RA1SHD_2048x32M8CCG
XI0_73 BL BL WL_69 WL_69 VSS VDD RA1SHD_2048x32M8CCG
XI0_74 BL BL WL_70 WL_70 VSS VDD RA1SHD_2048x32M8CCG
XI0_75 BL BL WL_71 WL_71 VSS VDD RA1SHD_2048x32M8CCG
XI0_76 BL BL WL_72 WL_72 VSS VDD RA1SHD_2048x32M8CCG
XI0_77 BL BL WL_73 WL_73 VSS VDD RA1SHD_2048x32M8CCG
XI0_78 BL BL WL_74 WL_74 VSS VDD RA1SHD_2048x32M8CCG
XI0_79 BL BL WL_75 WL_75 VSS VDD RA1SHD_2048x32M8CCG
XI0_8 BL BL WL_4 WL_4 VSS VDD RA1SHD_2048x32M8CCG
XI0_80 BL BL WL_76 WL_76 VSS VDD RA1SHD_2048x32M8CCG
XI0_81 BL BL WL_77 WL_77 VSS VDD RA1SHD_2048x32M8CCG
XI0_82 BL BL WL_78 WL_78 VSS VDD RA1SHD_2048x32M8CCG
XI0_83 BL BL WL_79 WL_79 VSS VDD RA1SHD_2048x32M8CCG
XI0_84 BL BL WL_80 WL_80 VSS VDD RA1SHD_2048x32M8CCG
XI0_85 BL BL WL_81 WL_81 VSS VDD RA1SHD_2048x32M8CCG
XI0_86 BL BL WL_82 WL_82 VSS VDD RA1SHD_2048x32M8CCG
XI0_87 BL BL WL_83 WL_83 VSS VDD RA1SHD_2048x32M8CCG
XI0_88 BL BL WL_84 WL_84 VSS VDD RA1SHD_2048x32M8CCG
XI0_89 BL BL WL_85 WL_85 VSS VDD RA1SHD_2048x32M8CCG
XI0_9 BL BL WL_5 WL_5 VSS VDD RA1SHD_2048x32M8CCG
XI0_90 BL BL WL_86 WL_86 VSS VDD RA1SHD_2048x32M8CCG
XI0_91 BL BL WL_87 WL_87 VSS VDD RA1SHD_2048x32M8CCG
XI0_92 BL BL WL_88 WL_88 VSS VDD RA1SHD_2048x32M8CCG
XI0_93 BL BL WL_89 WL_89 VSS VDD RA1SHD_2048x32M8CCG
XI0_94 BL BL WL_90 WL_90 VSS VDD RA1SHD_2048x32M8CCG
XI0_95 BL BL WL_91 WL_91 VSS VDD RA1SHD_2048x32M8CCG
XI0_96 BL BL WL_92 WL_92 VSS VDD RA1SHD_2048x32M8CCG
XI0_97 BL BL WL_93 WL_93 VSS VDD RA1SHD_2048x32M8CCG
XI0_98 BL BL WL_94 WL_94 VSS VDD RA1SHD_2048x32M8CCG
XI0_99 BL BL WL_95 WL_95 VSS VDD RA1SHD_2048x32M8CCG
XI1_10 WL_6 WL_7 VSS VDD RA1SHD_2048x32M8FCR
XI1_100 WL_96 WL_97 VSS VDD RA1SHD_2048x32M8FCR
XI1_102 WL_98 WL_99 VSS VDD RA1SHD_2048x32M8FCR
XI1_104 WL_100 WL_101 VSS VDD RA1SHD_2048x32M8FCR
XI1_106 WL_102 WL_103 VSS VDD RA1SHD_2048x32M8FCR
XI1_108 WL_104 WL_105 VSS VDD RA1SHD_2048x32M8FCR
XI1_110 WL_106 WL_107 VSS VDD RA1SHD_2048x32M8FCR
XI1_112 WL_108 WL_109 VSS VDD RA1SHD_2048x32M8FCR
XI1_114 WL_110 WL_111 VSS VDD RA1SHD_2048x32M8FCR
XI1_116 WL_112 WL_113 VSS VDD RA1SHD_2048x32M8FCR
XI1_118 WL_114 WL_115 VSS VDD RA1SHD_2048x32M8FCR
XI1_12 WL_8 WL_9 VSS VDD RA1SHD_2048x32M8FCR
XI1_120 WL_116 WL_117 VSS VDD RA1SHD_2048x32M8FCR
XI1_122 WL_118 WL_119 VSS VDD RA1SHD_2048x32M8FCR
XI1_124 WL_120 WL_121 VSS VDD RA1SHD_2048x32M8FCR
XI1_126 WL_122 WL_123 VSS VDD RA1SHD_2048x32M8FCR
XI1_128 WL_124 WL_125 VSS VDD RA1SHD_2048x32M8FCR
XI1_130 WL_126 WL_127 VSS VDD RA1SHD_2048x32M8FCR
XI1_132 WL_128 WL_129 VSS VDD RA1SHD_2048x32M8FCR
XI1_134 WL_130 WL_131 VSS VDD RA1SHD_2048x32M8FCR
XI1_136 WL_132 WL_133 VSS VDD RA1SHD_2048x32M8FCR
XI1_138 WL_134 WL_135 VSS VDD RA1SHD_2048x32M8FCR
XI1_14 WL_10 WL_11 VSS VDD RA1SHD_2048x32M8FCR
XI1_140 WL_136 WL_137 VSS VDD RA1SHD_2048x32M8FCR
XI1_142 WL_138 WL_139 VSS VDD RA1SHD_2048x32M8FCR
XI1_144 WL_140 WL_141 VSS VDD RA1SHD_2048x32M8FCR
XI1_146 WL_142 WL_143 VSS VDD RA1SHD_2048x32M8FCR
XI1_148 WL_144 WL_145 VSS VDD RA1SHD_2048x32M8FCR
XI1_150 WL_146 WL_147 VSS VDD RA1SHD_2048x32M8FCR
XI1_152 WL_148 WL_149 VSS VDD RA1SHD_2048x32M8FCR
XI1_154 WL_150 WL_151 VSS VDD RA1SHD_2048x32M8FCR
XI1_156 WL_152 WL_153 VSS VDD RA1SHD_2048x32M8FCR
XI1_158 WL_154 WL_155 VSS VDD RA1SHD_2048x32M8FCR
XI1_16 WL_12 WL_13 VSS VDD RA1SHD_2048x32M8FCR
XI1_160 WL_156 WL_157 VSS VDD RA1SHD_2048x32M8FCR
XI1_162 WL_158 WL_159 VSS VDD RA1SHD_2048x32M8FCR
XI1_164 WL_160 WL_161 VSS VDD RA1SHD_2048x32M8FCR
XI1_166 WL_162 WL_163 VSS VDD RA1SHD_2048x32M8FCR
XI1_168 WL_164 WL_165 VSS VDD RA1SHD_2048x32M8FCR
XI1_170 WL_166 WL_167 VSS VDD RA1SHD_2048x32M8FCR
XI1_172 WL_168 WL_169 VSS VDD RA1SHD_2048x32M8FCR
XI1_174 WL_170 WL_171 VSS VDD RA1SHD_2048x32M8FCR
XI1_176 WL_172 WL_173 VSS VDD RA1SHD_2048x32M8FCR
XI1_178 WL_174 WL_175 VSS VDD RA1SHD_2048x32M8FCR
XI1_18 WL_14 WL_15 VSS VDD RA1SHD_2048x32M8FCR
XI1_180 WL_176 WL_177 VSS VDD RA1SHD_2048x32M8FCR
XI1_182 WL_178 WL_179 VSS VDD RA1SHD_2048x32M8FCR
XI1_184 WL_180 WL_181 VSS VDD RA1SHD_2048x32M8FCR
XI1_186 WL_182 WL_183 VSS VDD RA1SHD_2048x32M8FCR
XI1_188 WL_184 WL_185 VSS VDD RA1SHD_2048x32M8FCR
XI1_190 WL_186 WL_187 VSS VDD RA1SHD_2048x32M8FCR
XI1_192 WL_188 WL_189 VSS VDD RA1SHD_2048x32M8FCR
XI1_194 WL_190 WL_191 VSS VDD RA1SHD_2048x32M8FCR
XI1_196 WL_192 WL_193 VSS VDD RA1SHD_2048x32M8FCR
XI1_198 WL_194 WL_195 VSS VDD RA1SHD_2048x32M8FCR
XI1_20 WL_16 WL_17 VSS VDD RA1SHD_2048x32M8FCR
XI1_200 WL_196 WL_197 VSS VDD RA1SHD_2048x32M8FCR
XI1_202 WL_198 WL_199 VSS VDD RA1SHD_2048x32M8FCR
XI1_204 WL_200 WL_201 VSS VDD RA1SHD_2048x32M8FCR
XI1_206 WL_202 WL_203 VSS VDD RA1SHD_2048x32M8FCR
XI1_208 WL_204 WL_205 VSS VDD RA1SHD_2048x32M8FCR
XI1_210 WL_206 WL_207 VSS VDD RA1SHD_2048x32M8FCR
XI1_212 WL_208 WL_209 VSS VDD RA1SHD_2048x32M8FCR
XI1_214 WL_210 WL_211 VSS VDD RA1SHD_2048x32M8FCR
XI1_216 WL_212 WL_213 VSS VDD RA1SHD_2048x32M8FCR
XI1_218 WL_214 WL_215 VSS VDD RA1SHD_2048x32M8FCR
XI1_22 WL_18 WL_19 VSS VDD RA1SHD_2048x32M8FCR
XI1_220 WL_216 WL_217 VSS VDD RA1SHD_2048x32M8FCR
XI1_222 WL_218 WL_219 VSS VDD RA1SHD_2048x32M8FCR
XI1_224 WL_220 WL_221 VSS VDD RA1SHD_2048x32M8FCR
XI1_226 WL_222 WL_223 VSS VDD RA1SHD_2048x32M8FCR
XI1_228 WL_224 WL_225 VSS VDD RA1SHD_2048x32M8FCR
XI1_230 WL_226 WL_227 VSS VDD RA1SHD_2048x32M8FCR
XI1_232 WL_228 WL_229 VSS VDD RA1SHD_2048x32M8FCR
XI1_234 WL_230 WL_231 VSS VDD RA1SHD_2048x32M8FCR
XI1_236 WL_232 WL_233 VSS VDD RA1SHD_2048x32M8FCR
XI1_238 WL_234 WL_235 VSS VDD RA1SHD_2048x32M8FCR
XI1_24 WL_20 WL_21 VSS VDD RA1SHD_2048x32M8FCR
XI1_240 WL_236 WL_237 VSS VDD RA1SHD_2048x32M8FCR
XI1_242 WL_238 WL_239 VSS VDD RA1SHD_2048x32M8FCR
XI1_244 WL_240 WL_241 VSS VDD RA1SHD_2048x32M8FCR
XI1_246 WL_242 WL_243 VSS VDD RA1SHD_2048x32M8FCR
XI1_248 WL_244 WL_245 VSS VDD RA1SHD_2048x32M8FCR
XI1_250 WL_246 WL_247 VSS VDD RA1SHD_2048x32M8FCR
XI1_252 WL_248 WL_249 VSS VDD RA1SHD_2048x32M8FCR
XI1_254 WL_250 WL_251 VSS VDD RA1SHD_2048x32M8FCR
XI1_256 WL_252 WL_253 VSS VDD RA1SHD_2048x32M8FCR
XI1_258 WL_254 WL_255 VSS VDD RA1SHD_2048x32M8FCR
XI1_26 WL_22 WL_23 VSS VDD RA1SHD_2048x32M8FCR
XI1_260 VSS VDD RA1SHD_2048x32M8FCUR
XI1_28 WL_24 WL_25 VSS VDD RA1SHD_2048x32M8FCR
XI1_30 WL_26 WL_27 VSS VDD RA1SHD_2048x32M8FCR
XI1_32 WL_28 WL_29 VSS VDD RA1SHD_2048x32M8FCR
XI1_34 WL_30 WL_31 VSS VDD RA1SHD_2048x32M8FCR
XI1_36 WL_32 WL_33 VSS VDD RA1SHD_2048x32M8FCR
XI1_38 WL_34 WL_35 VSS VDD RA1SHD_2048x32M8FCR
XI1_4 WL_0 WL_1 VSS VDD RA1SHD_2048x32M8FCR
XI1_40 WL_36 WL_37 VSS VDD RA1SHD_2048x32M8FCR
XI1_42 WL_38 WL_39 VSS VDD RA1SHD_2048x32M8FCR
XI1_44 WL_40 WL_41 VSS VDD RA1SHD_2048x32M8FCR
XI1_46 WL_42 WL_43 VSS VDD RA1SHD_2048x32M8FCR
XI1_48 WL_44 WL_45 VSS VDD RA1SHD_2048x32M8FCR
XI1_50 WL_46 WL_47 VSS VDD RA1SHD_2048x32M8FCR
XI1_52 WL_48 WL_49 VSS VDD RA1SHD_2048x32M8FCR
XI1_54 WL_50 WL_51 VSS VDD RA1SHD_2048x32M8FCR
XI1_56 WL_52 WL_53 VSS VDD RA1SHD_2048x32M8FCR
XI1_58 WL_54 WL_55 VSS VDD RA1SHD_2048x32M8FCR
XI1_6 WL_2 WL_3 VSS VDD RA1SHD_2048x32M8FCR
XI1_60 WL_56 WL_57 VSS VDD RA1SHD_2048x32M8FCR
XI1_62 WL_58 WL_59 VSS VDD RA1SHD_2048x32M8FCR
XI1_64 WL_60 WL_61 VSS VDD RA1SHD_2048x32M8FCR
XI1_66 WL_62 WL_63 VSS VDD RA1SHD_2048x32M8FCR
XI1_68 WL_64 WL_65 VSS VDD RA1SHD_2048x32M8FCR
XI1_70 WL_66 WL_67 VSS VDD RA1SHD_2048x32M8FCR
XI1_72 WL_68 WL_69 VSS VDD RA1SHD_2048x32M8FCR
XI1_74 WL_70 WL_71 VSS VDD RA1SHD_2048x32M8FCR
XI1_76 WL_72 WL_73 VSS VDD RA1SHD_2048x32M8FCR
XI1_78 WL_74 WL_75 VSS VDD RA1SHD_2048x32M8FCR
XI1_8 WL_4 WL_5 VSS VDD RA1SHD_2048x32M8FCR
XI1_80 WL_76 WL_77 VSS VDD RA1SHD_2048x32M8FCR
XI1_82 WL_78 WL_79 VSS VDD RA1SHD_2048x32M8FCR
XI1_84 WL_80 WL_81 VSS VDD RA1SHD_2048x32M8FCR
XI1_86 WL_82 WL_83 VSS VDD RA1SHD_2048x32M8FCR
XI1_88 WL_84 WL_85 VSS VDD RA1SHD_2048x32M8FCR
XI1_90 WL_86 WL_87 VSS VDD RA1SHD_2048x32M8FCR
XI1_92 WL_88 WL_89 VSS VDD RA1SHD_2048x32M8FCR
XI1_94 WL_90 WL_91 VSS VDD RA1SHD_2048x32M8FCR
XI1_96 WL_92 WL_93 VSS VDD RA1SHD_2048x32M8FCR
XI1_98 WL_94 WL_95 VSS VDD RA1SHD_2048x32M8FCR
.ENDS RA1SHD_2048x32M8LEFT_CAP
****
.SUBCKT RA1SHD_2048x32M8FCBWRO8 BWEN D Q VSS VDD
** RA1SHD_2048x32M8FCBWRO8: 2 flat devices **
d1 VSS Q DN 0.2304P 2.32U
d2 VSS D DN 0.2304P 2.32U
.ENDS RA1SHD_2048x32M8FCBWRO8
****
.SUBCKT RA1SHD_2048x32M8IO8 BWE BWEMX BWEN D DI_ DPN DPU DW DW_ D_ GBWEN GTP
+  OE_ Q QI SP STUBWE STUBWEI UTIDMX WE VSS VDD
** RA1SHD_2048x32M8IO8: 60 flat devices **
m1 QI DPU VSS VSS N L=0.18U W=3.45U AD=1.656P PD=4.41U AS=1.656P PS=4.41U
m10 QPD OEI_ VSS VSS N L=0.18U W=0.72U AD=0.3456P PD=1.68U AS=0.3456P PS=1.68U
m11 QIL QI VDD VDD P L=0.18U W=1.27U AD=0.6096P PD=2.23U AS=0.6096P PS=2.23U
m12 QIL QI VSS VSS N L=0.18U W=0.72U AD=0.3456P PD=1.68U AS=0.3456P PS=1.68U
m13 SPN SP VDD VDD P L=0.18U W=0.47U AD=0.2256P PD=1.43U AS=0.2256P PS=1.43U
m14 SPN SP VSS VSS N L=0.18U W=0.31U AD=0.1488P PD=1.27U AS=0.1488P PS=1.27U
m15 DWPD GTPND DWI VSS N L=0.18U W=0.72U AD=0.3456P PD=1.68U AS=0.3456P
+  PS=1.68U
m16 DWPD DW VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m17 DWPD DW VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m18 DWPD GTP DWI VDD P L=0.18U W=0.91U AD=0.4368P PD=1.87U AS=0.4368P PS=1.87U
m19 DW_PU GTPND DNWI VSS N L=0.18U W=0.72U AD=0.3456P PD=1.68U AS=0.3456P
+  PS=1.68U
m2 QI DPN VDD VDD P L=0.18U W=9.12U AD=4.3776P PD=10.08U AS=4.3776P PS=10.08U
m20 DW_PU GTP DNWI VDD P L=0.18U W=0.91U AD=0.4368P PD=1.87U AS=0.4368P
+  PS=1.87U
m21 GTPND GTP VDD VDD P L=0.18U W=0.5U AD=0.24P PD=1.46U AS=0.24P PS=1.46U
m22 GTPND GTP VSS VSS N L=0.18U W=0.34U AD=0.1632P PD=1.3U AS=0.1632P PS=1.3U
m23 DI DI_ VDD VDD P L=0.18U W=1.82U AD=0.8736P PD=2.78U AS=0.8736P PS=2.78U
m24 DI DI_ VSS VSS N L=0.18U W=0.89U AD=0.4272P PD=1.85U AS=0.4272P PS=1.85U
m25 DN DI VDD VDD P L=0.18U W=1.25U AD=0.6P PD=2.21U AS=0.6P PS=2.21U
m26 DN DI VSS VSS N L=0.18U W=0.61U AD=0.2928P PD=1.57U AS=0.2928P PS=1.57U
m27 WEI N58 VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P PS=2.44U
m28 WEI N58 VSS VSS N L=0.18U W=0.86U AD=0.4128P PD=1.82U AS=0.4128P PS=1.82U
m29 OEI OEI_ VDD VDD P L=0.18U W=1.23U AD=0.5904P PD=2.19U AS=0.5904P PS=2.19U
m3 Q QPU VDD VDD P L=0.18U W=10.8U AD=5.184P PD=11.76U AS=5.184P PS=11.76U
m30 OEI OEI_ VSS VSS N L=0.18U W=0.64U AD=0.3072P PD=1.6U AS=0.3072P PS=1.6U
m31 QI SP N84 VDD P L=0.18U W=2U AD=0.96P PD=2.96U AS=0.96P PS=2.96U
m32 N84 QIL VDD VDD P L=0.18U W=2U AD=0.96P PD=2.96U AS=0.96P PS=2.96U
m33 QI SPN N83 VSS N L=0.18U W=2U AD=0.96P PD=2.96U AS=0.96P PS=2.96U
m34 N83 QIL VSS VSS N L=0.18U W=2U AD=0.96P PD=2.96U AS=0.96P PS=2.96U
m35 N41 OE_ VDD VDD P L=0.18U W=0.78U AD=0.3744P PD=1.74U AS=0.3744P PS=1.74U
m36 N41 OE_ VSS VSS N L=0.18U W=0.4U AD=0.192P PD=1.36U AS=0.192P PS=1.36U
m37 N58 WE VDD VDD P L=0.18U W=0.58U AD=0.2784P PD=1.54U AS=0.2784P PS=1.54U
m38 N58 WE VSS VSS N L=0.18U W=0.29U AD=0.1392P PD=1.25U AS=0.1392P PS=1.25U
m39 DWI WEI VDD VDD P L=0.18U W=1.77U AD=0.8496P PD=2.73U AS=0.8496P PS=2.73U
m4 Q QPD VSS VSS N L=0.18U W=7.2U AD=3.456P PD=8.16U AS=3.456P PS=8.16U
m40 N85 WEI VSS VSS N L=0.18U W=1.58U AD=0.7584P PD=2.54U AS=0.7584P PS=2.54U
m41 DWI DI VDD VDD P L=0.18U W=1.77U AD=0.8496P PD=2.73U AS=0.8496P PS=2.73U
m42 DWI DI N85 VSS N L=0.18U W=1.58U AD=0.7584P PD=2.54U AS=0.7584P PS=2.54U
m43 DNWI WEI VDD VDD P L=0.18U W=1.77U AD=0.8496P PD=2.73U AS=0.8496P PS=2.73U
m44 N86 WEI VSS VSS N L=0.18U W=1.58U AD=0.7584P PD=2.54U AS=0.7584P PS=2.54U
m45 DNWI DN VDD VDD P L=0.18U W=1.77U AD=0.8496P PD=2.73U AS=0.8496P PS=2.73U
m46 DNWI DN N86 VSS N L=0.18U W=1.58U AD=0.7584P PD=2.54U AS=0.7584P PS=2.54U
m47 D_ D VDD VDD P L=0.18U W=0.71U AD=0.3408P PD=1.67U AS=0.3408P PS=1.67U
m48 D_ D VSS VSS N L=0.18U W=0.35U AD=0.168P PD=1.31U AS=0.168P PS=1.31U
m49 QPU OEI_ QI VDD P L=0.18U W=0.34U AD=0.1632P PD=1.3U AS=0.1632P PS=1.3U
m5 OEI_ N41 VDD VDD P L=0.18U W=2.18U AD=1.0464P PD=3.14U AS=1.0464P PS=3.14U
m50 QPD OEI QI VSS N L=0.18U W=0.65U AD=0.312P PD=1.61U AS=0.312P PS=1.61U
m51 DW DWPD VDD VDD P L=0.18U W=5.98U AD=2.8704P PD=6.94U AS=2.8704P PS=6.94U
m52 DW DWPD VSS VSS N L=0.18U W=2.96U AD=1.4208P PD=3.92U AS=1.4208P PS=3.92U
m53 DW_PU DW_ VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m54 DW_PU DW_ VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m55 DW_ DW_PU VDD VDD P L=0.18U W=5.98U AD=2.8704P PD=6.94U AS=2.8704P
+  PS=6.94U
m56 DW_ DW_PU VSS VSS N L=0.18U W=2.96U AD=1.4208P PD=3.92U AS=1.4208P
+  PS=3.92U
m57 N87 VSS VDD VDD P L=0.18U W=0.44U AD=0.2112P PD=1.4U AS=0.2112P PS=1.4U
m58 BWE VSS VSS VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m59 BWE GBWEN N87 VDD P L=0.18U W=0.44U AD=0.2112P PD=1.4U AS=0.2112P PS=1.4U
m6 OEI_ N41 VSS VSS N L=0.18U W=1.1U AD=0.528P PD=2.06U AS=0.528P PS=2.06U
m60 BWE GBWEN VSS VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m7 QPD OEI_ QI VDD P L=0.18U W=6.92U AD=3.3216P PD=7.88U AS=3.3216P PS=7.88U
m8 QPU OEI QI VSS N L=0.18U W=3.24U AD=1.5552P PD=4.2U AS=1.5552P PS=4.2U
m9 QPU OEI VDD VDD P L=0.18U W=1.74U AD=0.8352P PD=2.7U AS=0.8352P PS=2.7U
.ENDS RA1SHD_2048x32M8IO8
****
.SUBCKT RA1SHD_2048x32M8IOX BWE BWEN D DPN DPU DW DW_ D_ GTP OE_ Q QI SP VSS
+  VDD
** RA1SHD_2048x32M8IOX: 60 flat devices **
XI0_0 BWE VSS BWEN D D_ DPN DPU DW DW_ D_ BWEN GTP OE_ Q QI SP VSS VSS VSS BWE
+  VSS VDD RA1SHD_2048x32M8IO8
.ENDS RA1SHD_2048x32M8IOX
****
.SUBCKT RA1SHD_2048x32M8SA8 DPN DPU DR DR_ DW DW_ GTP SP VSS VDD
** RA1SHD_2048x32M8SA8: 43 flat devices **
m1 N24 SRCD VSS VSS N L=0.18U W=2.4U AD=0.576P PD=0.48U AS=1.152P PS=3.36U
m10 DPN SDN VDD VDD P L=0.18U W=1.54U AD=0.7392P PD=2.5U AS=0.7392P PS=2.5U
m11 DPN SDN VSS VSS N L=0.18U W=3.4U AD=1.632P PD=4.36U AS=1.632P PS=4.36U
m12 SP SPN VDD VDD P L=0.18U W=1.98U AD=0.9504P PD=2.94U AS=0.9504P PS=2.94U
m13 SP SPN VSS VSS N L=0.18U W=1.34U AD=0.6432P PD=2.3U AS=0.6432P PS=2.3U
m14 GTPN GTP VDD VDD P L=0.18U W=1U AD=0.48P PD=1.96U AS=0.48P PS=1.96U
m15 GTPN GTP VSS VSS N L=0.18U W=0.31U AD=0.1488P PD=1.27U AS=0.1488P PS=1.27U
m16 ND1 GTPN VDD VDD P L=0.18U W=0.58U AD=0.2784P PD=1.54U AS=0.2784P PS=1.54U
m17 ND1 GTPN VSS VSS N L=0.18U W=0.33U AD=0.1584P PD=1.29U AS=0.1584P PS=1.29U
m18 ND2 ND1 VDD VDD P L=0.18U W=1.65U AD=0.792P PD=2.61U AS=0.792P PS=2.61U
m19 ND2 ND1 VSS VSS N L=0.18U W=0.71U AD=0.3408P PD=1.67U AS=0.3408P PS=1.67U
m2 SD SP DR VDD P L=0.18U W=3.2U AD=0.64P PD=0 AS=2.4576P PS=7.04U
m20 N42 DRP VSS VSS N L=0.18U W=1.22U AD=0.2928P PD=0.48U AS=0.5856P PS=2.18U
m21 SPN GTPN N42 VSS N L=0.18U W=0.83U AD=0.3984P PD=1.79U AS=0.1992P PS=0.48U
m22 SPN DRP VDD VDD P L=0.18U W=1.11U AD=0.5328P PD=2.07U AS=0.5328P PS=2.07U
m23 SPN GTPN VDD VDD P L=0.18U W=0.66U AD=0.3168P PD=1.62U AS=0.3168P PS=1.62U
m24 DRP ND2 VDD VDD P L=0.18U W=3U AD=1.44P PD=3.96U AS=1.44P PS=3.96U
m25 DRP ND2 VSS VSS N L=0.18U W=2U AD=0.96P PD=2.96U AS=0.96P PS=2.96U
m26 DR_ DRP VDD VDD P L=0.18U W=3.66U AD=1.7568P PD=4.62U AS=1.7568P PS=4.62U
m27 DR DRP VDD VDD P L=0.18U W=3.66U AD=1.7568P PD=4.62U AS=1.7568P PS=4.62U
m28 DR DRP DR_ VDD P L=0.18U W=4.68U AD=2.2464P PD=5.64U AS=2.2464P PS=5.64U
m29 SD_ SD SRC VSS N L=0.34U W=4.2U AD=1.1025P PD=0 AS=2.9376P PS=8.04U
m3 SD_ SP DR_ VDD P L=0.18U W=3.2U AD=0.64P PD=0 AS=2.4576P PS=7.04U
m30 SD SD_ SRC VSS N L=0.34U W=4.2U AD=1.1025P PD=0 AS=2.9376P PS=8.04U
m31 SD_ SD SRC VSS N L=0.34U W=4.2U AD=1.1025P PD=0 AS=2.9376P PS=8.04U
m32 SD SD_ SRC VSS N L=0.34U W=4.2U AD=1.1025P PD=0 AS=2.9376P PS=8.04U
m33 SRC GTPN N24 VSS N L=0.18U W=2.4U AD=1.152P PD=3.36U AS=0.576P PS=0.48U
m34 SRCD SRCPU VDD VDD P L=0.18U W=0.62U AD=0.2976P PD=1.58U AS=0.2976P
+  PS=1.58U
m35 SRCD SRCPU VSS VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m36 SRCPU DRP VDD VDD P L=0.18U W=0.91U AD=0.4368P PD=1.87U AS=0.4368P
+  PS=1.87U
m37 SRCPU DRP VSS VSS N L=0.18U W=0.33U AD=0.1584P PD=1.29U AS=0.1584P
+  PS=1.29U
m38 VDD SRCPU SRC VSS N L=0.18U W=1.66U AD=0.7968P PD=2.62U AS=0.7968P
+  PS=2.62U
m39 SD SRCD SD_ VDD P L=0.18U W=0.68U AD=0.3264P PD=1.64U AS=0.3264P PS=1.64U
m4 SD_ SD VDD VDD P L=0.18U W=0.68U AD=0.3264P PD=1.64U AS=0.3264P PS=1.64U
m40 SRC GTPN N54 VSS N L=0.18U W=2.4U AD=1.152P PD=3.36U AS=0.576P PS=0.48U
m41 N54 SRCD VSS VSS N L=0.18U W=2.4U AD=0.576P PD=0.48U AS=1.152P PS=3.36U
m42 SRC VSS VSS VSS N L=0.34U W=4.2U AD=1.1025P PD=0 AS=2.9376P PS=8.04U
m43 SRC VSS VSS VSS N L=0.34U W=4.2U AD=1.1025P PD=0 AS=2.9376P PS=8.04U
m5 SD SD_ VDD VDD P L=0.18U W=0.68U AD=0.3264P PD=1.64U AS=0.3264P PS=1.64U
m6 SDN SD VDD VDD P L=0.18U W=1.64U AD=0.7872P PD=2.6U AS=0.7872P PS=2.6U
m7 SDN SD VSS VSS N L=0.18U W=0.87U AD=0.4176P PD=1.83U AS=0.4176P PS=1.83U
m8 DPU SD_ VDD VDD P L=0.18U W=1.64U AD=0.7872P PD=2.6U AS=0.7872P PS=2.6U
m9 DPU SD_ VSS VSS N L=0.18U W=0.58U AD=0.2784P PD=1.54U AS=0.2784P PS=1.54U
.ENDS RA1SHD_2048x32M8SA8
****
.SUBCKT RA1SHD_2048x32M8CD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0
+  G1 GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8CD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD P L=0.18U W=3.24U AD=2.4768P PD=7.08U AS=0.6561P PS=0
m10 BL1_ BL1PD VSS VSS N L=0.18U W=10U AD=4.7952P PD=10.95U AS=4.7952P
+  PS=10.95U
m11 BL1_PD CS1 DW_ VDD P L=0.18U W=1.66U AD=0.79488P PD=2.616U AS=0.79488P
+  PS=2.616U
m12 BL1_PD CS1 VSS VSS N L=0.18U W=1.32U AD=0.6312P PD=2.275U AS=0.6312P
+  PS=2.275U
m13 BL1_ CS1 DR_ VDD P L=0.18U W=3.24U AD=2.4768P PD=7.08U AS=0.6561P PS=0
m14 BL1PD CS1 DW VDD P L=0.18U W=1.66U AD=0.79488P PD=2.616U AS=0.79488P
+  PS=2.616U
m15 BL1PD CS1 VSS VSS N L=0.18U W=1.32U AD=0.6312P PD=2.275U AS=0.6312P
+  PS=2.275U
m16 BL1 BL1_PD VSS VSS N L=0.18U W=10U AD=4.7952P PD=10.95U AS=4.7952P
+  PS=10.95U
m17 BL0_ YI VDD VDD P L=0.18U W=8.87U AD=4.25712P PD=9.829U AS=4.25712P
+  PS=9.829U
m18 BL0 YI VDD VDD P L=0.18U W=8.87U AD=4.25712P PD=9.829U AS=4.25712P
+  PS=9.829U
m19 BL0 YI BL0_ VDD P L=0.18U W=8.87U AD=4.2576P PD=9.83U AS=4.2576P PS=9.83U
m2 BL0 BL0PD VSS VSS N L=0.18U W=10U AD=4.7952P PD=10.95U AS=4.7952P PS=10.95U
m20 BL1 YI VDD VDD P L=0.18U W=8.87U AD=4.25712P PD=9.829U AS=4.25712P
+  PS=9.829U
m21 BL1_ YI VDD VDD P L=0.18U W=8.87U AD=4.25712P PD=9.829U AS=4.25712P
+  PS=9.829U
m22 BL1_ YI BL1 VDD P L=0.18U W=8.87U AD=5.664P PD=12.76U AS=5.664P PS=12.76U
m23 CS0 A0_ VDD VDD P L=0.18U W=1.87U AD=0.89664P PD=2.828U AS=0.89664P
+  PS=2.828U
m24 N65 A0_ VSS VSS N L=0.18U W=2.97U AD=1.4232P PD=3.925U AS=1.4232P
+  PS=3.925U
m25 CS0 YI VDD VDD P L=0.18U W=1.87U AD=0.89664P PD=2.828U AS=0.89664P
+  PS=2.828U
m26 CS0 YI N65 VSS N L=0.18U W=2.97U AD=1.4232P PD=3.925U AS=1.4232P PS=3.925U
m27 CS1 A0 VDD VDD P L=0.18U W=1.87U AD=0.89664P PD=2.828U AS=0.89664P
+  PS=2.828U
m28 N66 A0 VSS VSS N L=0.18U W=2.97U AD=1.4232P PD=3.925U AS=1.4232P PS=3.925U
m29 CS1 YI VDD VDD P L=0.18U W=1.87U AD=0.89664P PD=2.828U AS=0.89664P
+  PS=2.828U
m3 BL0_PD CS0 DW VDD P L=0.18U W=1.66U AD=0.79488P PD=2.616U AS=0.79488P
+  PS=2.616U
m30 CS1 YI N66 VSS N L=0.18U W=2.97U AD=1.4232P PD=3.925U AS=1.4232P PS=3.925U
m31 YCDSEL_ G0 VDD VDD P L=0.18U W=0.3U AD=0.144P PD=1.26U AS=0.144P PS=1.26U
m32 N67 G0 VSS VSS N L=0.18U W=0.25U AD=0.12P PD=1.21U AS=0.12P PS=1.21U
m33 YCDSEL_ G1 VDD VDD P L=0.18U W=0.3U AD=0.144P PD=1.26U AS=0.144P PS=1.26U
m34 YCDSEL_ G1 N67 VSS N L=0.18U W=0.25U AD=0.12P PD=1.21U AS=0.12P PS=1.21U
m35 YCDSEL YCDSEL_ VDD VDD P L=0.18U W=0.42U AD=0.2016P PD=1.38U AS=0.2016P
+  PS=1.38U
m36 YCDSEL YCDSEL_ VSS VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m37 N37 YCDSEL_ GTP VDD P L=0.18U W=0.43U AD=0.20832P PD=1.394U AS=0.20832P
+  PS=1.394U
m38 N37 YCDSEL_ VSS VSS N L=0.18U W=0.82U AD=0.3936P PD=1.78U AS=0.3936P
+  PS=1.78U
m39 YI WL1_EN_ VDD VDD P L=0.18U W=12U AD=5.76P PD=12.96U AS=5.76P PS=12.96U
m4 BL0_PD CS0 VSS VSS N L=0.18U W=1.32U AD=0.6312P PD=2.275U AS=0.6312P
+  PS=2.275U
m40 YI WL1_EN_ VSS VSS N L=0.18U W=6.1U AD=2.93184P PD=7.068U AS=2.93184P
+  PS=7.068U
m41 WL1_EN_ N37 VDD VDD P L=0.18U W=3.7U AD=1.776P PD=4.66U AS=1.776P PS=4.66U
m42 WL1_EN_ N37 VSS VSS N L=0.18U W=1.83U AD=0.87792P PD=2.789U AS=0.87792P
+  PS=2.789U
m43 N37 YCDSEL GTP VSS N L=0.18U W=0.43U AD=0.20832P PD=1.394U AS=0.20832P
+  PS=1.394U
m5 BL0 CS0 DR VDD P L=0.18U W=3.24U AD=2.4768P PD=7.08U AS=0.6561P PS=0
m6 BL0PD CS0 DW_ VDD P L=0.18U W=1.66U AD=0.79488P PD=2.616U AS=0.79488P
+  PS=2.616U
m7 BL0PD CS0 VSS VSS N L=0.18U W=1.32U AD=0.6312P PD=2.275U AS=0.6312P
+  PS=2.275U
m8 BL0_ BL0_PD VSS VSS N L=0.18U W=10U AD=4.7952P PD=10.95U AS=4.7952P
+  PS=10.95U
m9 BL1 CS1 DR VDD P L=0.18U W=3.24U AD=2.4768P PD=7.08U AS=0.6561P PS=0
.ENDS RA1SHD_2048x32M8CD
****
.SUBCKT RA1SHD_2048x32M8CDX A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_
+  G0 G1 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8CDX: 43 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1 GTP DR DR_ DW DW_
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8CD
.ENDS RA1SHD_2048x32M8CDX
****
.SUBCKT RA1SHD_2048x32M8MUX_CD_ODD A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0__0
+  BL0__1 BL0__2 BL0__3 BL1_0 BL1_1 BL1_2 BL1_3 BL1__0 BL1__1 BL1__2 BL1__3
+  DRSA_0 DRSA_1 DWSA_0 DWSA_1 GTP STUBDR_0 STUBDR_1 STUBDR__0 STUBDR__1
+  STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8MUX_CD_ODD: 172 flat devices **
XI0_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 STUBDR_0 DRSA_0 STUBDR__0 STUBDW_0
+  DWSA_0 STUBDW__0 YP0_3 VDD GTP STUBDR_1 STUBDR__1 STUBDW_1 STUBDW__1 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8CD
XI1_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 STUBDR_0 STUBDR_0 STUBDR__0 STUBDW_0
+  STUBDW_0 STUBDW__0 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD_2048x32M8CDX
XI2_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 STUBDR_0 STUBDR__0 STUBDR__0 STUBDW_0
+  STUBDW__0 STUBDW__0 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD_2048x32M8CDX
XI3_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 STUBDR_0 DRSA_1 STUBDR__0 STUBDW_0
+  DWSA_1 STUBDW__0 YP0_0 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD_2048x32M8CDX
.ENDS RA1SHD_2048x32M8MUX_CD_ODD
****
.SUBCKT RA1SHD_2048x32M8CCP BL BL_ WL WP VSS VDD
** RA1SHD_2048x32M8CCP: 6 flat devices **
m1 BL WP CORED VSS N L=0.265U W=0.22U AD=0.1272P PD=1.225U AS=0.1272P
+  PS=1.225U
m2 BL_ WP CORED_ VSS N L=0.265U W=0.22U AD=0.1272P PD=1.225U AS=0.1272P
+  PS=1.225U
m3 CORED_ CORED VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
m5 CORED CORED_ VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
.ENDS RA1SHD_2048x32M8CCP
****
.SUBCKT RA1SHD_2048x32M8BIT_MUX_1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 WL WP VSS VDD
** RA1SHD_2048x32M8BIT_MUX_1: 48 flat devices **
XI0_0 BL_0 BL__0 WL WP VSS VDD RA1SHD_2048x32M8CCG
XI1_0 BL_1 BL__1 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI2_0 BL_2 BL__2 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI3_0 BL_3 BL__3 WL WP VSS VDD RA1SHD_2048x32M8CCG
XI4_0 BL_4 BL__4 WL WP VSS VDD RA1SHD_2048x32M8CCG
XI5_0 BL_5 BL__5 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI6_0 BL_6 BL__6 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI7_0 BL_7 BL__7 WL WP VSS VDD RA1SHD_2048x32M8CCG
.ENDS RA1SHD_2048x32M8BIT_MUX_1
****
.SUBCKT RA1SHD_2048x32M8BIT_MUX_0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 WL WP VSS VDD
** RA1SHD_2048x32M8BIT_MUX_0: 48 flat devices **
XI0_0 BL_0 BL__0 WL WP VSS VDD RA1SHD_2048x32M8CCG
XI1_0 BL_1 BL__1 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI2_0 BL_2 BL__2 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI3_0 BL_3 BL__3 WL WP VSS VDD RA1SHD_2048x32M8CCG
XI4_0 BL_4 BL__4 WL WP VSS VDD RA1SHD_2048x32M8CCG
XI5_0 BL_5 BL__5 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI6_0 BL_6 BL__6 WL WP VSS VDD RA1SHD_2048x32M8CCP
XI7_0 BL_7 BL__7 WL WP VSS VDD RA1SHD_2048x32M8CCG
.ENDS RA1SHD_2048x32M8BIT_MUX_0
****
.SUBCKT RA1SHD_2048x32M8BIT_COL BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9
+  WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21
+  WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33
+  WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45
+  WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57
+  WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69
+  WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81
+  WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93
+  WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102 WP_103 WP_104
+  WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112 WP_113 WP_114
+  WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122 WP_123 WP_124
+  WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132 WP_133 WP_134
+  WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142 WP_143 WP_144
+  WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152 WP_153 WP_154
+  WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162 WP_163 WP_164
+  WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172 WP_173 WP_174
+  WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182 WP_183 WP_184
+  WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192 WP_193 WP_194
+  WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202 WP_203 WP_204
+  WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212 WP_213 WP_214
+  WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222 WP_223 WP_224
+  WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232 WP_233 WP_234
+  WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242 WP_243 WP_244
+  WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252 WP_253 WP_254
+  WP_255 VSS VDD
** RA1SHD_2048x32M8BIT_COL: 12288 flat devices **
XI0_1 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 WL_0 WP_0 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_9 WP_9 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_100 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_99 WP_99 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_101 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_100 WP_100 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_102 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_101 WP_101 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_103 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_102 WP_102 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_104 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_103 WP_103 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_105 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_104 WP_104 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_106 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_105 WP_105 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_107 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_106 WP_106 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_108 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_107 WP_107 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_109 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_108 WP_108 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_11 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_10 WP_10 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_110 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_109 WP_109 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_111 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_110 WP_110 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_112 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_111 WP_111 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_113 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_112 WP_112 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_114 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_113 WP_113 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_115 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_114 WP_114 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_116 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_115 WP_115 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_117 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_116 WP_116 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_118 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_117 WP_117 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_119 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_118 WP_118 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_11 WP_11 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_120 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_119 WP_119 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_121 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_120 WP_120 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_122 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_121 WP_121 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_123 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_122 WP_122 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_124 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_123 WP_123 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_125 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_124 WP_124 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_126 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_125 WP_125 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_127 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_126 WP_126 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_128 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_127 WP_127 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_129 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_128 WP_128 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_13 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_12 WP_12 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_130 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_129 WP_129 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_131 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_130 WP_130 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_132 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_131 WP_131 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_133 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_132 WP_132 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_134 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_133 WP_133 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_135 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_134 WP_134 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_136 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_135 WP_135 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_137 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_136 WP_136 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_138 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_137 WP_137 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_139 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_138 WP_138 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_13 WP_13 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_140 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_139 WP_139 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_141 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_140 WP_140 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_142 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_141 WP_141 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_143 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_142 WP_142 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_144 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_143 WP_143 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_145 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_144 WP_144 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_146 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_145 WP_145 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_147 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_146 WP_146 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_148 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_147 WP_147 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_149 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_148 WP_148 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_14 WP_14 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_150 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_149 WP_149 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_151 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_150 WP_150 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_152 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_151 WP_151 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_153 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_152 WP_152 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_154 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_153 WP_153 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_155 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_154 WP_154 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_156 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_155 WP_155 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_157 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_156 WP_156 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_158 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_157 WP_157 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_159 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_158 WP_158 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_15 WP_15 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_160 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_159 WP_159 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_161 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_160 WP_160 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_162 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_161 WP_161 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_163 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_162 WP_162 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_164 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_163 WP_163 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_165 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_164 WP_164 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_166 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_165 WP_165 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_167 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_166 WP_166 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_168 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_167 WP_167 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_169 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_168 WP_168 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_17 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_16 WP_16 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_170 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_169 WP_169 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_171 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_170 WP_170 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_172 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_171 WP_171 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_173 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_172 WP_172 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_174 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_173 WP_173 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_175 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_174 WP_174 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_176 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_175 WP_175 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_177 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_176 WP_176 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_178 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_177 WP_177 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_179 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_178 WP_178 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_17 WP_17 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_180 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_179 WP_179 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_181 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_180 WP_180 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_182 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_181 WP_181 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_183 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_182 WP_182 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_184 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_183 WP_183 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_185 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_184 WP_184 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_186 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_185 WP_185 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_187 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_186 WP_186 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_188 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_187 WP_187 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_189 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_188 WP_188 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_19 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_18 WP_18 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_190 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_189 WP_189 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_191 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_190 WP_190 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_192 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_191 WP_191 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_193 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_192 WP_192 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_194 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_193 WP_193 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_195 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_194 WP_194 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_196 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_195 WP_195 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_197 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_196 WP_196 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_198 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_197 WP_197 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_199 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_198 WP_198 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_1 WP_1 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_19 WP_19 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_200 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_199 WP_199 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_201 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_200 WP_200 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_202 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_201 WP_201 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_203 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_202 WP_202 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_204 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_203 WP_203 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_205 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_204 WP_204 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_206 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_205 WP_205 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_207 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_206 WP_206 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_208 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_207 WP_207 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_209 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_208 WP_208 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_21 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_20 WP_20 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_210 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_209 WP_209 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_211 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_210 WP_210 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_212 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_211 WP_211 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_213 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_212 WP_212 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_214 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_213 WP_213 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_215 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_214 WP_214 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_216 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_215 WP_215 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_217 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_216 WP_216 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_218 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_217 WP_217 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_219 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_218 WP_218 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_21 WP_21 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_220 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_219 WP_219 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_221 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_220 WP_220 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_222 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_221 WP_221 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_223 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_222 WP_222 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_224 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_223 WP_223 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_225 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_224 WP_224 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_226 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_225 WP_225 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_227 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_226 WP_226 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_228 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_227 WP_227 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_229 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_228 WP_228 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_23 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_22 WP_22 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_230 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_229 WP_229 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_231 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_230 WP_230 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_232 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_231 WP_231 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_233 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_232 WP_232 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_234 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_233 WP_233 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_235 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_234 WP_234 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_236 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_235 WP_235 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_237 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_236 WP_236 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_238 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_237 WP_237 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_239 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_238 WP_238 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_23 WP_23 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_240 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_239 WP_239 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_241 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_240 WP_240 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_242 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_241 WP_241 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_243 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_242 WP_242 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_244 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_243 WP_243 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_245 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_244 WP_244 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_246 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_245 WP_245 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_247 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_246 WP_246 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_248 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_247 WP_247 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_249 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_248 WP_248 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_25 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_24 WP_24 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_250 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_249 WP_249 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_251 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_250 WP_250 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_252 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_251 WP_251 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_253 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_252 WP_252 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_254 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_253 WP_253 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_255 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_254 WP_254 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_256 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_255 WP_255 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_25 WP_25 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_27 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_26 WP_26 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_27 WP_27 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_29 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_28 WP_28 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_3 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 WL_2 WP_2 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_29 WP_29 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_31 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_30 WP_30 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_31 WP_31 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_33 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_32 WP_32 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_33 WP_33 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_35 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_34 WP_34 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_35 WP_35 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_37 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_36 WP_36 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_38 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_37 WP_37 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_39 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_38 WP_38 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_3 WP_3 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_39 WP_39 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_41 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_40 WP_40 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_42 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_41 WP_41 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_43 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_42 WP_42 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_43 WP_43 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_45 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_44 WP_44 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_46 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_45 WP_45 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_47 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_46 WP_46 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_47 WP_47 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_49 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_48 WP_48 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_5 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 WL_4 WP_4 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_50 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_49 WP_49 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_51 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_50 WP_50 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_51 WP_51 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_53 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_52 WP_52 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_54 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_53 WP_53 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_55 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_54 WP_54 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_55 WP_55 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_57 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_56 WP_56 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_58 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_57 WP_57 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_59 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_58 WP_58 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_5 WP_5 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_59 WP_59 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_61 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_60 WP_60 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_62 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_61 WP_61 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_63 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_62 WP_62 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_64 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_63 WP_63 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_65 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_64 WP_64 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_66 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_65 WP_65 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_67 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_66 WP_66 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_68 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_67 WP_67 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_69 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_68 WP_68 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_7 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 WL_6 WP_6 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_70 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_69 WP_69 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_71 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_70 WP_70 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_72 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_71 WP_71 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_73 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_72 WP_72 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_74 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_73 WP_73 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_75 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_74 WP_74 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_76 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_75 WP_75 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_77 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_76 WP_76 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_78 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_77 WP_77 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_79 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_78 WP_78 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_7 WP_7 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_80 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_79 WP_79 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_81 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_80 WP_80 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_82 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_81 WP_81 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_83 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_82 WP_82 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_84 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_83 WP_83 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_85 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_84 WP_84 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_86 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_85 WP_85 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_87 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_86 WP_86 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_88 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_87 WP_87 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_89 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_88 WP_88 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_9 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 WL_8 WP_8 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_90 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_89 WP_89 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_91 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_90 WP_90 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_92 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_91 WP_91 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_93 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_92 WP_92 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_94 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_93 WP_93 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_95 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_94 WP_94 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_96 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_95 WP_95 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_97 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_96 WP_96 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
XI0_98 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_97 WP_97 VSS VDD RA1SHD_2048x32M8BIT_MUX_0
XI0_99 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 WL_98 WP_98 VSS VDD RA1SHD_2048x32M8BIT_MUX_1
.ENDS RA1SHD_2048x32M8BIT_COL
****
.SUBCKT RA1SHD_2048x32M8MCOL_ODD_RO8 A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BWEN D GTP_0 GTP_1
+  GTP_2 OE_ Q STUBDR_0 STUBDR_1 STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1
+  STUBDW__0 STUBDW__1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8MCOL_ODD_RO8: 12565 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD_2048x32M8FCBWRO8
XI0_1 BWE BWEN D DPN DPU STUBDW_0 STUBDW__0 D_ GTP_0 OE_ Q QI SP VSS VDD
+  RA1SHD_2048x32M8IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_1 SP VSS VDD
+  RA1SHD_2048x32M8SA8
XI0_3 A0 A0_ BL__0 BL_3 BL__4 BL_7 BL_0 BL__3 BL_4 BL__7 BL_1 BL__2 BL_5 BL__6
+  BL__1 BL_2 BL__5 BL_6 VSS VSS VSS VSS GTP_2 STUBDR_0 STUBDR_1 STUBDR__0
+  STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MUX_CD_ODD
XI0_4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 VSS VDD RA1SHD_2048x32M8BIT_COL
.ENDS RA1SHD_2048x32M8MCOL_ODD_RO8
****
.SUBCKT RA1SHD_2048x32M8FCBWM8 BWEN D Q VSS VDD
** RA1SHD_2048x32M8FCBWM8: 2 flat devices **
d1 VSS Q DN 0.2304P 2.32U
d2 VSS D DN 0.2304P 2.32U
.ENDS RA1SHD_2048x32M8FCBWM8
****
.SUBCKT RA1SHD_2048x32M8MUX_CD_EVEN A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0__0
+  BL0__1 BL0__2 BL0__3 BL1_0 BL1_1 BL1_2 BL1_3 BL1__0 BL1__1 BL1__2 BL1__3
+  DRSA_0 DRSA_1 DRSA_2 DRSA_3 DWSA_0 DWSA_1 DWSA_2 DWSA_3 GTP STUBDR STUBDR_
+  STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8MUX_CD_EVEN: 172 flat devices **
XI0_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_1 DRSA_0 DRSA_2 DWSA_1 DWSA_0
+  DWSA_2 YP0_0 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD_2048x32M8CDX
XI1_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_1 DRSA_1 DRSA_2 DWSA_1 DWSA_1
+  DWSA_2 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD_2048x32M8CDX
XI2_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_1 DRSA_2 DRSA_2 DWSA_1 DWSA_2
+  DWSA_2 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SHD_2048x32M8CDX
XI3_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 DRSA_1 DRSA_3 DRSA_2 DWSA_1 DWSA_3
+  DWSA_2 YP0_3 VDD GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8CD
.ENDS RA1SHD_2048x32M8MUX_CD_EVEN
****
.SUBCKT RA1SHD_2048x32M8MCOL_EVEN_M8 A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BWEN D GTP_0 GTP_1
+  GTP_2 OE_ Q STUBDR_0 STUBDR_1 STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1
+  STUBDW__0 STUBDW__1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8MCOL_EVEN_M8: 12565 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD_2048x32M8FCBWM8
XI0_1 BWE BWEN D DPN DPU STUBDW_1 STUBDW__1 D_ GTP_0 OE_ Q QI SP VSS VDD
+  RA1SHD_2048x32M8IOX
XI0_2 DPN DPU STUBDR_1 STUBDR__1 STUBDW_1 STUBDW__1 GTP_1 SP VSS VDD
+  RA1SHD_2048x32M8SA8
XI0_3 A0 A0_ BL__0 BL_3 BL__4 BL_7 BL_0 BL__3 BL_4 BL__7 BL_1 BL__2 BL_5 BL__6
+  BL__1 BL_2 BL__5 BL_6 VSS STUBDR_1 STUBDR__1 VSS VSS STUBDW_1 STUBDW__1 VSS
+  GTP_2 STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MUX_CD_EVEN
XI0_4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 VSS VDD RA1SHD_2048x32M8BIT_COL
.ENDS RA1SHD_2048x32M8MCOL_EVEN_M8
****
.SUBCKT RA1SHD_2048x32M8MCOL_ODD_M8 A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BWEN D GTP_0 GTP_1
+  GTP_2 OE_ Q STUBDR_0 STUBDR_1 STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1
+  STUBDW__0 STUBDW__1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8MCOL_ODD_M8: 12565 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SHD_2048x32M8FCBWM8
XI0_1 BWE BWEN D DPN DPU STUBDW_0 STUBDW__0 D_ GTP_0 OE_ Q QI SP VSS VDD
+  RA1SHD_2048x32M8IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_1 SP VSS VDD
+  RA1SHD_2048x32M8SA8
XI0_3 A0 A0_ BL__0 BL_3 BL__4 BL_7 BL_0 BL__3 BL_4 BL__7 BL_1 BL__2 BL_5 BL__6
+  BL__1 BL_2 BL__5 BL_6 VSS VSS VSS VSS GTP_2 STUBDR_0 STUBDR_1 STUBDR__0
+  STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MUX_CD_ODD
XI0_4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 VSS VDD RA1SHD_2048x32M8BIT_COL
.ENDS RA1SHD_2048x32M8MCOL_ODD_M8
****
.SUBCKT RA1SHD_2048x32M8FLCCSTRAP WL VSS VDD
** RA1SHD_2048x32M8FLCCSTRAP: 2 flat devices **
MM1 N5 WL VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM2 N6 WL VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
.ENDS RA1SHD_2048x32M8FLCCSTRAP
****
.SUBCKT RA1SHD_2048x32M8BIT_COL_STRAP WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 VSS VDD
** RA1SHD_2048x32M8BIT_COL_STRAP: 512 flat devices **
XI0_1 WL_0 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_10 WL_9 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_100 WL_99 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_101 WL_100 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_102 WL_101 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_103 WL_102 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_104 WL_103 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_105 WL_104 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_106 WL_105 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_107 WL_106 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_108 WL_107 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_109 WL_108 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_11 WL_10 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_110 WL_109 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_111 WL_110 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_112 WL_111 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_113 WL_112 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_114 WL_113 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_115 WL_114 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_116 WL_115 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_117 WL_116 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_118 WL_117 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_119 WL_118 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_12 WL_11 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_120 WL_119 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_121 WL_120 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_122 WL_121 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_123 WL_122 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_124 WL_123 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_125 WL_124 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_126 WL_125 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_127 WL_126 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_128 WL_127 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_129 WL_128 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_13 WL_12 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_130 WL_129 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_131 WL_130 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_132 WL_131 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_133 WL_132 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_134 WL_133 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_135 WL_134 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_136 WL_135 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_137 WL_136 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_138 WL_137 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_139 WL_138 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_14 WL_13 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_140 WL_139 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_141 WL_140 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_142 WL_141 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_143 WL_142 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_144 WL_143 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_145 WL_144 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_146 WL_145 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_147 WL_146 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_148 WL_147 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_149 WL_148 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_15 WL_14 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_150 WL_149 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_151 WL_150 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_152 WL_151 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_153 WL_152 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_154 WL_153 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_155 WL_154 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_156 WL_155 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_157 WL_156 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_158 WL_157 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_159 WL_158 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_16 WL_15 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_160 WL_159 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_161 WL_160 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_162 WL_161 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_163 WL_162 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_164 WL_163 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_165 WL_164 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_166 WL_165 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_167 WL_166 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_168 WL_167 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_169 WL_168 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_17 WL_16 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_170 WL_169 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_171 WL_170 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_172 WL_171 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_173 WL_172 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_174 WL_173 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_175 WL_174 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_176 WL_175 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_177 WL_176 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_178 WL_177 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_179 WL_178 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_18 WL_17 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_180 WL_179 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_181 WL_180 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_182 WL_181 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_183 WL_182 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_184 WL_183 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_185 WL_184 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_186 WL_185 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_187 WL_186 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_188 WL_187 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_189 WL_188 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_19 WL_18 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_190 WL_189 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_191 WL_190 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_192 WL_191 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_193 WL_192 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_194 WL_193 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_195 WL_194 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_196 WL_195 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_197 WL_196 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_198 WL_197 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_199 WL_198 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_2 WL_1 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_20 WL_19 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_200 WL_199 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_201 WL_200 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_202 WL_201 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_203 WL_202 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_204 WL_203 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_205 WL_204 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_206 WL_205 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_207 WL_206 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_208 WL_207 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_209 WL_208 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_21 WL_20 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_210 WL_209 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_211 WL_210 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_212 WL_211 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_213 WL_212 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_214 WL_213 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_215 WL_214 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_216 WL_215 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_217 WL_216 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_218 WL_217 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_219 WL_218 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_22 WL_21 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_220 WL_219 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_221 WL_220 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_222 WL_221 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_223 WL_222 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_224 WL_223 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_225 WL_224 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_226 WL_225 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_227 WL_226 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_228 WL_227 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_229 WL_228 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_23 WL_22 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_230 WL_229 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_231 WL_230 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_232 WL_231 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_233 WL_232 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_234 WL_233 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_235 WL_234 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_236 WL_235 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_237 WL_236 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_238 WL_237 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_239 WL_238 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_24 WL_23 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_240 WL_239 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_241 WL_240 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_242 WL_241 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_243 WL_242 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_244 WL_243 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_245 WL_244 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_246 WL_245 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_247 WL_246 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_248 WL_247 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_249 WL_248 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_25 WL_24 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_250 WL_249 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_251 WL_250 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_252 WL_251 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_253 WL_252 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_254 WL_253 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_255 WL_254 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_256 WL_255 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_26 WL_25 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_27 WL_26 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_28 WL_27 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_29 WL_28 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_3 WL_2 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_30 WL_29 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_31 WL_30 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_32 WL_31 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_33 WL_32 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_34 WL_33 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_35 WL_34 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_36 WL_35 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_37 WL_36 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_38 WL_37 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_39 WL_38 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_4 WL_3 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_40 WL_39 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_41 WL_40 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_42 WL_41 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_43 WL_42 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_44 WL_43 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_45 WL_44 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_46 WL_45 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_47 WL_46 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_48 WL_47 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_49 WL_48 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_5 WL_4 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_50 WL_49 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_51 WL_50 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_52 WL_51 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_53 WL_52 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_54 WL_53 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_55 WL_54 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_56 WL_55 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_57 WL_56 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_58 WL_57 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_59 WL_58 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_6 WL_5 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_60 WL_59 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_61 WL_60 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_62 WL_61 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_63 WL_62 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_64 WL_63 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_65 WL_64 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_66 WL_65 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_67 WL_66 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_68 WL_67 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_69 WL_68 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_7 WL_6 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_70 WL_69 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_71 WL_70 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_72 WL_71 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_73 WL_72 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_74 WL_73 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_75 WL_74 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_76 WL_75 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_77 WL_76 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_78 WL_77 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_79 WL_78 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_8 WL_7 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_80 WL_79 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_81 WL_80 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_82 WL_81 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_83 WL_82 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_84 WL_83 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_85 WL_84 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_86 WL_85 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_87 WL_86 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_88 WL_87 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_89 WL_88 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_9 WL_8 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_90 WL_89 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_91 WL_90 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_92 WL_91 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_93 WL_92 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_94 WL_93 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_95 WL_94 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_96 WL_95 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_97 WL_96 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_98 WL_97 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
XI0_99 WL_98 VSS VDD RA1SHD_2048x32M8FLCCSTRAP
.ENDS RA1SHD_2048x32M8BIT_COL_STRAP
****
.SUBCKT RA1SHD_2048x32M8COL_STRAP A0 A0_ DR DR_ DW DW_ GTP_0 GTP_1 GTP_2 OE_
+  STUBBW WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8COL_STRAP: 512 flat devices **
XI0_3 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 VSS VDD
+  RA1SHD_2048x32M8BIT_COL_STRAP
.ENDS RA1SHD_2048x32M8COL_STRAP
****
.SUBCKT RA1SHD_2048x32M8MCOL_EVEN_LE8 A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BWEN D GTP_0
+  GTP_1 GTP_2 OE_ Q STUBDR_0 STUBDR_1 STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1
+  STUBDW__0 STUBDW__1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8MCOL_EVEN_LE8: 12563 flat devices **
XI0_1 BWE BWEN D DPN DPU STUBDW_1 STUBDW__1 D_ GTP_0 OE_ Q QI SP VSS VDD
+  RA1SHD_2048x32M8IOX
XI0_2 DPN DPU STUBDR_1 STUBDR__1 STUBDW_1 STUBDW__1 GTP_1 SP VSS VDD
+  RA1SHD_2048x32M8SA8
XI0_3 A0 A0_ BL__0 BL_3 BL__4 BL_7 BL_0 BL__3 BL_4 BL__7 BL_1 BL__2 BL_5 BL__6
+  BL__1 BL_2 BL__5 BL_6 VSS STUBDR_1 STUBDR__1 VSS VSS STUBDW_1 STUBDW__1 VSS
+  GTP_2 STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MUX_CD_EVEN
XI0_4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38
+  WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50
+  WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62
+  WP_63 WP_64 WP_65 WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74
+  WP_75 WP_76 WP_77 WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86
+  WP_87 WP_88 WP_89 WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98
+  WP_99 WP_100 WP_101 WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109
+  WP_110 WP_111 WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119
+  WP_120 WP_121 WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129
+  WP_130 WP_131 WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139
+  WP_140 WP_141 WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149
+  WP_150 WP_151 WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159
+  WP_160 WP_161 WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169
+  WP_170 WP_171 WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179
+  WP_180 WP_181 WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189
+  WP_190 WP_191 WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199
+  WP_200 WP_201 WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209
+  WP_210 WP_211 WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219
+  WP_220 WP_221 WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229
+  WP_230 WP_231 WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239
+  WP_240 WP_241 WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249
+  WP_250 WP_251 WP_252 WP_253 WP_254 WP_255 VSS VDD RA1SHD_2048x32M8BIT_COL
.ENDS RA1SHD_2048x32M8MCOL_EVEN_LE8
****
.SUBCKT RA1SHD_2048x32M8COL_STRAPX A0 A0_ DR DR_ DW DW_ GTP_0 GTP_1 GTP_2 OE_
+  WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8COL_STRAPX: 512 flat devices **
XI0_3 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 VSS VDD
+  RA1SHD_2048x32M8BIT_COL_STRAP
.ENDS RA1SHD_2048x32M8COL_STRAPX
****
.SUBCKT RA1SHD_2048x32M8WING_16_LEFT A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19
+  BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31
+  BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43
+  BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55
+  BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67
+  BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79
+  BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91
+  BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 BWEN_0 BWEN_1 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10
+  D_11 D_12 D_13 D_14 D_15 GTP_0 GTP_1 GTP_2 OE_ Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6
+  Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 STUBDR_0 STUBDR_1 STUBDR__0
+  STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD
** RA1SHD_2048x32M8WING_16_LEFT: 202572 flat devices **
XI0_0 A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BWEN_0 D_0 GTP_0 GTP_1 GTP_2 OE_ Q_0 STUBDR_0_66
+  STUBDR_1 STUBDR__0_64 STUBDR__1 STUBDW_0_68 STUBDW_1 STUBDW__0_70 STUBDW__1
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD RA1SHD_2048x32M8MCOL_ODD_RO8
XI10_0 A0 A0_ BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL__64 BL__65
+  BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BWEN_1 D_8 GTP_0 GTP_1 GTP_2 OE_
+  Q_8 STUBDR_0_2 STUBDR_1_10 STUBDR__0_0 STUBDR__1_8 STUBDW_0_4 STUBDW_1_12
+  STUBDW__0_6 STUBDW__1_14 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_RO8
XI11_0 A0 A0_ BL_79 BL_78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL__79 BL__78
+  BL__77 BL__76 BL__75 BL__74 BL__73 BL__72 BWEN_1 D_9 GTP_0 GTP_1 GTP_2 OE_
+  Q_9 STUBDR_0_2 STUBDR_1_18 STUBDR__0_0 STUBDR__1_16 STUBDW_0_4 STUBDW_1_20
+  STUBDW__0_6 STUBDW__1_22 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI12_0 A0 A0_ BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL__80 BL__81
+  BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BWEN_1 D_10 GTP_0 GTP_1 GTP_2 OE_
+  Q_10 STUBDR_0_26 STUBDR_1_18 STUBDR__0_24 STUBDR__1_16 STUBDW_0_28
+  STUBDW_1_20 STUBDW__0_30 STUBDW__1_22 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI13_0 A0 A0_ BL_95 BL_94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL__95 BL__94
+  BL__93 BL__92 BL__91 BL__90 BL__89 BL__88 BWEN_1 D_11 GTP_0 GTP_1 GTP_2 OE_
+  Q_11 STUBDR_0_26 STUBDR_1_34 STUBDR__0_24 STUBDR__1_32 STUBDW_0_28
+  STUBDW_1_36 STUBDW__0_30 STUBDW__1_38 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI14_0 A0 A0_ STUBDR_1_34 STUBDR__1_32 STUBDW_1_36 STUBDW__1_38 GTP_0 GTP_1
+  GTP_2 OE_ BWEN_1 VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8COL_STRAP
XI15_0 A0 A0_ BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BWEN_1 D_12 GTP_0
+  GTP_1 GTP_2 OE_ Q_12 STUBDR_0_42 STUBDR_1_34 STUBDR__0_40 STUBDR__1_32
+  STUBDW_0_44 STUBDW_1_36 STUBDW__0_46 STUBDW__1_38 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_ODD_M8
XI16_0 A0 A0_ BL_111 BL_110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL__111
+  BL__110 BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BWEN_1 D_13 GTP_0
+  GTP_1 GTP_2 OE_ Q_13 STUBDR_0_42 STUBDR_1_50 STUBDR__0_40 STUBDR__1_48
+  STUBDW_0_44 STUBDW_1_52 STUBDW__0_46 STUBDW__1_54 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_EVEN_M8
XI17_0 A0 A0_ BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL__112
+  BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BL__119 BWEN_1 D_14 GTP_0
+  GTP_1 GTP_2 OE_ Q_14 STUBDR_0_58 STUBDR_1_50 STUBDR__0_56 STUBDR__1_48
+  STUBDW_0_60 STUBDW_1_52 STUBDW__0_62 STUBDW__1_54 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_ODD_M8
XI18_0 A0 A0_ BL_127 BL_126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL__127
+  BL__126 BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BWEN_1 D_15 GTP_0
+  GTP_1 GTP_2 OE_ Q_15 STUBDR_0_58 STUBDR_0 STUBDR__0_56 STUBDR__0
+  STUBDW_0_60 STUBDW_0 STUBDW__0_62 STUBDW__0 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_EVEN_LE8
XI1_0 A0 A0_ BL_15 BL_14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL__15 BL__14
+  BL__13 BL__12 BL__11 BL__10 BL__9 BL__8 BWEN_0 D_1 GTP_0 GTP_1 GTP_2 OE_
+  Q_1 STUBDR_0_66 STUBDR_1_74 STUBDR__0_64 STUBDR__1_72 STUBDW_0_68
+  STUBDW_1_76 STUBDW__0_70 STUBDW__1_78 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI2_0 A0 A0_ BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL__16 BL__17
+  BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BWEN_0 D_2 GTP_0 GTP_1 GTP_2 OE_
+  Q_2 STUBDR_0_82 STUBDR_1_74 STUBDR__0_80 STUBDR__1_72 STUBDW_0_84
+  STUBDW_1_76 STUBDW__0_86 STUBDW__1_78 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI3_0 A0 A0_ BL_31 BL_30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL__31 BL__30
+  BL__29 BL__28 BL__27 BL__26 BL__25 BL__24 BWEN_0 D_3 GTP_0 GTP_1 GTP_2 OE_
+  Q_3 STUBDR_0_82 STUBDR_1_90 STUBDR__0_80 STUBDR__1_88 STUBDW_0_84
+  STUBDW_1_92 STUBDW__0_86 STUBDW__1_94 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI4_0 A0 A0_ STUBDR_1_90 STUBDR__1_88 STUBDW_1_92 STUBDW__1_94 GTP_0 GTP_1
+  GTP_2 OE_ BWEN_0 VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8COL_STRAP
XI5_0 A0 A0_ BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL__32 BL__33
+  BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BWEN_0 D_4 GTP_0 GTP_1 GTP_2 OE_
+  Q_4 STUBDR_0_98 STUBDR_1_90 STUBDR__0_96 STUBDR__1_88 STUBDW_0_100
+  STUBDW_1_92 STUBDW__0_102 STUBDW__1_94 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI6_0 A0 A0_ BL_47 BL_46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL__47 BL__46
+  BL__45 BL__44 BL__43 BL__42 BL__41 BL__40 BWEN_0 D_5 GTP_0 GTP_1 GTP_2 OE_
+  Q_5 STUBDR_0_98 STUBDR_1_106 STUBDR__0_96 STUBDR__1_104 STUBDW_0_100
+  STUBDW_1_108 STUBDW__0_102 STUBDW__1_110 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI7_0 A0 A0_ BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BWEN_0 D_6 GTP_0 GTP_1 GTP_2 OE_
+  Q_6 STUBDR_0_114 STUBDR_1_106 STUBDR__0_112 STUBDR__1_104 STUBDW_0_116
+  STUBDW_1_108 STUBDW__0_118 STUBDW__1_110 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI8_0 A0 A0_ BL_63 BL_62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL__63 BL__62
+  BL__61 BL__60 BL__59 BL__58 BL__57 BL__56 BWEN_0 D_7 GTP_0 GTP_1 GTP_2 OE_
+  Q_7 STUBDR_0_114 STUBDR_1_10 STUBDR__0_112 STUBDR__1_8 STUBDW_0_116
+  STUBDW_1_12 STUBDW__0_118 STUBDW__1_14 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_LE8
XI9_0 A0 A0_ STUBDR_1_10 STUBDR__1_8 STUBDW_1_12 STUBDW__1_14 GTP_0 GTP_1
+  GTP_2 OE_ VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8COL_STRAPX
.ENDS RA1SHD_2048x32M8WING_16_LEFT
****
.SUBCKT RA1SHD_2048x32M8FLMWSTRAP MWLB MWLT VSS VDD
** RA1SHD_2048x32M8FLMWSTRAP: 4 flat devices **
MM1 N5 MWLB VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM2 N6 MWLT VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM3 N8 MWLT VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM4 N7 MWLB VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
.ENDS RA1SHD_2048x32M8FLMWSTRAP
****
.SUBCKT RA1SHD_2048x32M8ADDR_CAP2 AGTPB AGTPT AY0 AY0_ GTP MWLB MWLT OEI_ WEI
+  WL0_0 WL0_1 WL0_2 WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11
+  WL0_12 WL0_13 WL0_14 WL0_15 WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21
+  WL0_22 WL0_23 WL0_24 WL0_25 WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL0_31
+  WL0_32 WL0_33 WL0_34 WL0_35 WL0_36 WL0_37 WL0_38 WL0_39 WL0_40 WL0_41
+  WL0_42 WL0_43 WL0_44 WL0_45 WL0_46 WL0_47 WL0_48 WL0_49 WL0_50 WL0_51
+  WL0_52 WL0_53 WL0_54 WL0_55 WL0_56 WL0_57 WL0_58 WL0_59 WL0_60 WL0_61
+  WL0_62 WL0_63 WL0_64 WL0_65 WL0_66 WL0_67 WL0_68 WL0_69 WL0_70 WL0_71
+  WL0_72 WL0_73 WL0_74 WL0_75 WL0_76 WL0_77 WL0_78 WL0_79 WL0_80 WL0_81
+  WL0_82 WL0_83 WL0_84 WL0_85 WL0_86 WL0_87 WL0_88 WL0_89 WL0_90 WL0_91
+  WL0_92 WL0_93 WL0_94 WL0_95 WL0_96 WL0_97 WL0_98 WL0_99 WL0_100 WL0_101
+  WL0_102 WL0_103 WL0_104 WL0_105 WL0_106 WL0_107 WL0_108 WL0_109 WL0_110
+  WL0_111 WL0_112 WL0_113 WL0_114 WL0_115 WL0_116 WL0_117 WL0_118 WL0_119
+  WL0_120 WL0_121 WL0_122 WL0_123 WL0_124 WL0_125 WL0_126 WL0_127 WL1_0 WL1_1
+  WL1_2 WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13
+  WL1_14 WL1_15 WL1_16 WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23
+  WL1_24 WL1_25 WL1_26 WL1_27 WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33
+  WL1_34 WL1_35 WL1_36 WL1_37 WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43
+  WL1_44 WL1_45 WL1_46 WL1_47 WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53
+  WL1_54 WL1_55 WL1_56 WL1_57 WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 WL1_63
+  WL1_64 WL1_65 WL1_66 WL1_67 WL1_68 WL1_69 WL1_70 WL1_71 WL1_72 WL1_73
+  WL1_74 WL1_75 WL1_76 WL1_77 WL1_78 WL1_79 WL1_80 WL1_81 WL1_82 WL1_83
+  WL1_84 WL1_85 WL1_86 WL1_87 WL1_88 WL1_89 WL1_90 WL1_91 WL1_92 WL1_93
+  WL1_94 WL1_95 WL1_96 WL1_97 WL1_98 WL1_99 WL1_100 WL1_101 WL1_102 WL1_103
+  WL1_104 WL1_105 WL1_106 WL1_107 WL1_108 WL1_109 WL1_110 WL1_111 WL1_112
+  WL1_113 WL1_114 WL1_115 WL1_116 WL1_117 WL1_118 WL1_119 WL1_120 WL1_121
+  WL1_122 WL1_123 WL1_124 WL1_125 WL1_126 WL1_127 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8ADDR_CAP2: 516 flat devices **
XI0_0 AY0 AY0_ VSS VSS VSS VSS GTP GTP GTP OEI_ VSS WEI WL0_0 WL1_0 WL1_1
+  WL0_1 WL0_2 WL1_2 WL1_3 WL0_3 WL0_4 WL1_4 WL1_5 WL0_5 WL0_6 WL1_6 WL1_7
+  WL0_7 WL0_8 WL1_8 WL1_9 WL0_9 WL0_10 WL1_10 WL1_11 WL0_11 WL0_12 WL1_12
+  WL1_13 WL0_13 WL0_14 WL1_14 WL1_15 WL0_15 WL0_16 WL1_16 WL1_17 WL0_17
+  WL0_18 WL1_18 WL1_19 WL0_19 WL0_20 WL1_20 WL1_21 WL0_21 WL0_22 WL1_22
+  WL1_23 WL0_23 WL0_24 WL1_24 WL1_25 WL0_25 WL0_26 WL1_26 WL1_27 WL0_27
+  WL0_28 WL1_28 WL1_29 WL0_29 WL0_30 WL1_30 WL1_31 WL0_31 WL0_32 WL1_32
+  WL1_33 WL0_33 WL0_34 WL1_34 WL1_35 WL0_35 WL0_36 WL1_36 WL1_37 WL0_37
+  WL0_38 WL1_38 WL1_39 WL0_39 WL0_40 WL1_40 WL1_41 WL0_41 WL0_42 WL1_42
+  WL1_43 WL0_43 WL0_44 WL1_44 WL1_45 WL0_45 WL0_46 WL1_46 WL1_47 WL0_47
+  WL0_48 WL1_48 WL1_49 WL0_49 WL0_50 WL1_50 WL1_51 WL0_51 WL0_52 WL1_52
+  WL1_53 WL0_53 WL0_54 WL1_54 WL1_55 WL0_55 WL0_56 WL1_56 WL1_57 WL0_57
+  WL0_58 WL1_58 WL1_59 WL0_59 WL0_60 WL1_60 WL1_61 WL0_61 WL0_62 WL1_62
+  WL1_63 WL0_63 WL0_64 WL1_64 WL1_65 WL0_65 WL0_66 WL1_66 WL1_67 WL0_67
+  WL0_68 WL1_68 WL1_69 WL0_69 WL0_70 WL1_70 WL1_71 WL0_71 WL0_72 WL1_72
+  WL1_73 WL0_73 WL0_74 WL1_74 WL1_75 WL0_75 WL0_76 WL1_76 WL1_77 WL0_77
+  WL0_78 WL1_78 WL1_79 WL0_79 WL0_80 WL1_80 WL1_81 WL0_81 WL0_82 WL1_82
+  WL1_83 WL0_83 WL0_84 WL1_84 WL1_85 WL0_85 WL0_86 WL1_86 WL1_87 WL0_87
+  WL0_88 WL1_88 WL1_89 WL0_89 WL0_90 WL1_90 WL1_91 WL0_91 WL0_92 WL1_92
+  WL1_93 WL0_93 WL0_94 WL1_94 WL1_95 WL0_95 WL0_96 WL1_96 WL1_97 WL0_97
+  WL0_98 WL1_98 WL1_99 WL0_99 WL0_100 WL1_100 WL1_101 WL0_101 WL0_102 WL1_102
+  WL1_103 WL0_103 WL0_104 WL1_104 WL1_105 WL0_105 WL0_106 WL1_106 WL1_107
+  WL0_107 WL0_108 WL1_108 WL1_109 WL0_109 WL0_110 WL1_110 WL1_111 WL0_111
+  WL0_112 WL1_112 WL1_113 WL0_113 WL0_114 WL1_114 WL1_115 WL0_115 WL0_116
+  WL1_116 WL1_117 WL0_117 WL0_118 WL1_118 WL1_119 WL0_119 WL0_120 WL1_120
+  WL1_121 WL0_121 WL0_122 WL1_122 WL1_123 WL0_123 WL0_124 WL1_124 WL1_125
+  WL0_125 WL0_126 WL1_126 WL1_127 WL0_127 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8COL_STRAP
XI0_1 MWLB MWLT VSS VDD RA1SHD_2048x32M8FLMWSTRAP
.ENDS RA1SHD_2048x32M8ADDR_CAP2
****
.SUBCKT RA1SHD_2048x32M8HXP24 A0 A1 ACONN0 ACONN1 AGTPB AGTPT AMX0 AMX1 AY0
+  AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8HXP24: 100 flat devices **
d15 VSS A1 DN 0.2304P 1.92U
d16 VSS BWEN DN 0.2304P 1.92U
d7 VSS A0 DN 0.2304P 1.92U
d8 VSS BWEN DN 0.2304P 1.92U
m1 N29 N36 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P PS=9.12U
m10 N33 N45 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P PS=4.98U
m100 XP_3 AP_I6-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U
+  AS=7.2864P PS=16.14U
m11 N32 ACONN1 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m12 N32 ACONN1 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m13 N45 ACONN1 VDD VDD P L=0.18U W=6.52U AD=3.1296P PD=7.48U AS=3.1296P
+  PS=7.48U
m14 N45 ACONN1 VSS VSS N L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P PS=4.16U
m17 AP_I5-APN1 N62 AP_I5-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m19 N62 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m2 N29 N36 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P PS=4.98U
m20 N62 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m21 AP_I5-AIN21 N29 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m22 AP_I5-AIN21 N29 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m23 N56 N33 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m24 N56 N33 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m25 N57 VSS VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m26 N57 VSS VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m27 N91 N57 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m28 N90 N56 N91 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m29 AP_I5-AIND1 AP_I5-AIN21 N90 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m3 N28 ACONN0 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m30 AP_I5-AIND1 N57 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m31 N89 N57 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m32 AP_I5-AIND1 N56 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m33 N88 N56 N89 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m35 AP_I5-AIND1 AP_I5-AIN21 N88 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m36 AP_I5-APN0 N73 AP_I5-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m38 N73 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m39 N73 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m4 N28 ACONN0 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m40 AP_I5-AIN20 N28 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m41 AP_I5-AIN20 N28 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m42 N95 N57 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m43 N94 N56 N95 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m44 AP_I5-AIND0 AP_I5-AIN20 N94 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m45 AP_I5-AIND0 N57 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m46 N93 N57 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m47 AP_I5-AIND0 N56 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m48 N92 N56 N93 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m5 N36 ACONN0 VDD VDD P L=0.18U W=6.52U AD=3.1296P PD=7.48U AS=3.1296P
+  PS=7.48U
m50 AP_I5-AIND0 AP_I5-AIN20 N92 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m51 AP_I5-APN1 XP_0 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m52 AP_I5-APN1 XP_0 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m53 XP_0 AP_I5-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m54 XP_0 AP_I5-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m55 AP_I5-APN0 XP_1 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m56 AP_I5-APN0 XP_1 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m57 XP_1 AP_I5-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m58 XP_1 AP_I5-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m59 AP_I6-APN1 N104 AP_I6-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m6 N36 ACONN0 VSS VSS N L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P PS=4.16U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m61 N104 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m62 N104 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m63 AP_I6-AIN21 N29 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m64 AP_I6-AIN21 N29 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m65 N98 N32 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m66 N98 N32 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m67 N99 VSS VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m68 N99 VSS VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m69 N133 N99 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m70 N132 N98 N133 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m71 AP_I6-AIND1 AP_I6-AIN21 N132 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m72 AP_I6-AIND1 N99 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m73 N131 N99 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m74 AP_I6-AIND1 N98 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m75 N130 N98 N131 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m77 AP_I6-AIND1 AP_I6-AIN21 N130 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m78 AP_I6-APN0 N115 AP_I6-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m80 N115 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m81 N115 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m82 AP_I6-AIN20 N28 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m83 AP_I6-AIN20 N28 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m84 N137 N99 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m85 N136 N98 N137 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m86 AP_I6-AIND0 AP_I6-AIN20 N136 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m87 AP_I6-AIND0 N99 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m88 N135 N99 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m89 AP_I6-AIND0 N98 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m9 N33 N45 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P PS=9.12U
m90 N134 N98 N135 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m92 AP_I6-AIND0 AP_I6-AIN20 N134 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m93 AP_I6-APN1 XP_2 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m94 AP_I6-APN1 XP_2 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m95 XP_2 AP_I6-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m96 XP_2 AP_I6-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m97 AP_I6-APN0 XP_3 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m98 AP_I6-APN0 XP_3 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m99 XP_3 AP_I6-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
.ENDS RA1SHD_2048x32M8HXP24
****
.SUBCKT RA1SHD_2048x32M8HXP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8HXP24X: 100 flat devices **
XI0_0 A0 A1 A0 A1 AGTPB AGTPT VSS VSS AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2
+  XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8HXP24
.ENDS RA1SHD_2048x32M8HXP24X
****
.SUBCKT RA1SHD_2048x32M8HXP38 A0 A1 A2 ACONN0 ACONN1 ACONN2 AGTPB AGTPT AMX0
+  AMX1 AMX2 AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8HXP38: 190 flat devices **
d175 VSS A2 DN 0.2304P 1.92U
d183 VSS A1 DN 0.2304P 1.92U
d191 VSS A0 DN 0.2304P 1.92U
d192 VSS BWEN DN 0.6912P 5.76U
m1 AP67-APN1 N54 AP67-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m10 N49 AI2_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m100 AP23-AIND1 N132 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m101 N164 N132 N165 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P
+  PS=7.2U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m103 AP23-AIND1 AP23-AIN21 N164 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m104 AP23-APN0 N149 AP23-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m106 N149 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m107 N149 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P
+  PS=1.9U
m108 AP23-AIN20 AI0 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m109 AP23-AIN20 AI0 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m11 N83 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m110 N171 N133 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m111 N170 N132 N171 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P
+  PS=7.2U
m112 AP23-AIND0 AP23-AIN20 N170 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m113 AP23-AIND0 N133 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m114 N169 N133 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m115 AP23-AIND0 N132 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m116 N168 N132 N169 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P
+  PS=7.2U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m118 AP23-AIND0 AP23-AIN20 N168 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m119 AP23-APN1 XP_3 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m12 N82 N48 N83 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m120 AP23-APN1 XP_3 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m121 XP_3 AP23-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m122 XP_3 AP23-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m123 AP23-APN0 XP_2 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m124 AP23-APN0 XP_2 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m125 XP_2 AP23-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m126 XP_2 AP23-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m127 AP01-APN1 N180 AP01-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m129 N180 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m13 AP67-AIND1 AP67-AIN21 N82 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m130 N180 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P
+  PS=1.9U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m133 N174 AI1 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m134 N174 AI1 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m135 N175 AI2 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m136 N175 AI2 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m137 N209 N175 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m138 N208 N174 N209 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P
+  PS=7.2U
m139 AP01-AIND1 AP01-AIN21 N208 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m14 AP67-AIND1 N49 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m140 AP01-AIND1 N175 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m141 N207 N175 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m142 AP01-AIND1 N174 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m143 N206 N174 N207 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P
+  PS=7.2U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m145 AP01-AIND1 AP01-AIN21 N206 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m146 AP01-APN0 N191 AP01-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m148 N191 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m149 N191 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P
+  PS=1.9U
m15 N81 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m150 AP01-AIN20 AI0 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m151 AP01-AIN20 AI0 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m152 N213 N175 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m153 N212 N174 N213 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P
+  PS=7.2U
m154 AP01-AIND0 AP01-AIN20 N212 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m155 AP01-AIND0 N175 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m156 N211 N175 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m157 AP01-AIND0 N174 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m158 N210 N174 N211 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P
+  PS=7.2U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m16 AP67-AIND1 N48 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m160 AP01-AIND0 AP01-AIN20 N210 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m161 AP01-APN1 XP_1 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m162 AP01-APN1 XP_1 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m163 XP_1 AP01-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m164 XP_1 AP01-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m165 AP01-APN0 XP_0 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m166 AP01-APN0 XP_0 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m167 XP_0 AP01-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m168 XP_0 AP01-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m169 AI2 N214 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m17 N80 N48 N81 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m170 AI2 N214 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m171 AI2_ ACONN2 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m172 AI2_ ACONN2 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m173 N214 ACONN2 VDD VDD P L=0.18U W=6.52U AD=3.1296P PD=7.48U AS=3.1296P
+  PS=7.48U
m174 N214 ACONN2 VSS VSS N L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P
+  PS=4.16U
m177 AI1 N223 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m178 AI1 N223 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m179 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m180 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m181 N223 ACONN1 VDD VDD P L=0.18U W=6.52U AD=3.1296P PD=7.48U AS=3.1296P
+  PS=7.48U
m182 N223 ACONN1 VSS VSS N L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P
+  PS=4.16U
m185 AI0 N232 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m186 AI0 N232 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m187 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m188 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m189 N232 ACONN0 VDD VDD P L=0.18U W=6.52U AD=3.1296P PD=7.48U AS=3.1296P
+  PS=7.48U
m19 AP67-AIND1 AP67-AIN21 N80 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m190 N232 ACONN0 VSS VSS N L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P
+  PS=4.16U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m20 AP67-APN0 N65 AP67-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m22 N65 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m23 N65 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m24 AP67-AIN20 AI0 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m25 AP67-AIN20 AI0 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m26 N87 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m27 N86 N48 N87 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m28 AP67-AIND0 AP67-AIN20 N86 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m29 AP67-AIND0 N49 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m3 N54 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P PS=2.44U
m30 N85 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m31 AP67-AIND0 N48 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m32 N84 N48 N85 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m34 AP67-AIND0 AP67-AIN20 N84 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m35 AP67-APN1 XP_7 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m36 AP67-APN1 XP_7 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m37 XP_7 AP67-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m38 XP_7 AP67-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m39 AP67-APN0 XP_6 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m4 N54 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m40 AP67-APN0 XP_6 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m41 XP_6 AP67-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m42 XP_6 AP67-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m43 AP45-APN1 N96 AP45-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m45 N96 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m46 N96 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m49 N90 AI1 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m50 N90 AI1 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m51 N91 AI2_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m52 N91 AI2_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m53 N125 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m54 N124 N90 N125 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m55 AP45-AIND1 AP45-AIN21 N124 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m56 AP45-AIND1 N91 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m57 N123 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m58 AP45-AIND1 N90 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m59 N122 N90 N123 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m61 AP45-AIND1 AP45-AIN21 N122 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m62 AP45-APN0 N107 AP45-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m64 N107 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m65 N107 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m66 AP45-AIN20 AI0 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m67 AP45-AIN20 AI0 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m68 N129 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m69 N128 N90 N129 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m7 N48 AI1_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m70 AP45-AIND0 AP45-AIN20 N128 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m71 AP45-AIND0 N91 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m72 N127 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m73 AP45-AIND0 N90 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m74 N126 N90 N127 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m76 AP45-AIND0 AP45-AIN20 N126 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m77 AP45-APN1 XP_5 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m78 AP45-APN1 XP_5 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m79 XP_5 AP45-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m8 N48 AI1_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m80 XP_5 AP45-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m81 AP45-APN0 XP_4 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m82 AP45-APN0 XP_4 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m83 XP_4 AP45-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m84 XP_4 AP45-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U AS=7.2864P
+  PS=16.14U
m85 AP23-APN1 N138 AP23-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m87 N138 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m88 N138 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m9 N49 AI2_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m91 N132 AI1_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m92 N132 AI1_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m93 N133 AI2 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m94 N133 AI2 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m95 N167 N133 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m96 N166 N132 N167 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m97 AP23-AIND1 AP23-AIN21 N166 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m98 AP23-AIND1 N133 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m99 N165 N133 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
.ENDS RA1SHD_2048x32M8HXP38
****
.SUBCKT RA1SHD_2048x32M8HXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI
+  XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8HXP38X: 190 flat devices **
XI0_0 A0 A1 A2 A0 A1 A2 AGTPB AGTPT VSS VSS VSS AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8HXP38
.ENDS RA1SHD_2048x32M8HXP38X
****
.SUBCKT RA1SHD_2048x32M8X_PRE_DECODE A0_0 A0_1 A0_2 A1_0 A1_1 A1_2 A2_0 A2_1
+  AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_0_1 XP_0_2 XP_1_0 XP_1_1
+  XP_1_2 XP_2_0 XP_2_1 XP_2_2 XP_3_0 XP_3_1 XP_3_2 XP_4_0 XP_4_1 XP_5_0
+  XP_5_1 XP_6_0 XP_6_1 XP_7_0 XP_7_1 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8X_PRE_DECODE: 480 flat devices **
XI0_0 A0_0 A1_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_1_0 XP_2_0 XP_3_0
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8HXP24X
XI1_0 A0_1 A1_1 A2_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_1 XP_1_1 XP_2_1
+  XP_3_1 XP_4_0 XP_5_0 XP_6_0 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8HXP38X
XI2_0 A0_2 A1_2 A2_1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_2 XP_1_2 XP_2_2
+  XP_3_2 XP_4_1 XP_5_1 XP_6_1 XP_7_1 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8HXP38X
.ENDS RA1SHD_2048x32M8X_PRE_DECODE
****
.SUBCKT RA1SHD_2048x32M8HYP24 A0 A1 ACONN0 ACONN1 AGTPB AGTPT AMX0 AMX1 AY0
+  AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SHD_2048x32M8HYP24: 100 flat devices **
d15 VSS A1 DN 0.2304P 1.92U
d16 VSS BWEN DN 0.2304P 1.92U
d7 VSS A0 DN 0.2304P 1.92U
d8 VSS BWEN DN 0.2304P 1.92U
m1 AI0 N28 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P PS=9.12U
m10 AI1 N37 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P PS=4.98U
m100 YP0_3 AP_I6-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U
+  AS=7.2864P PS=16.14U
m11 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m12 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m13 N37 ACONN1 VDD VDD P L=0.18U W=6.52U AD=3.1296P PD=7.48U AS=3.1296P
+  PS=7.48U
m14 N37 ACONN1 VSS VSS N L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P PS=4.16U
m17 AP_I5-APN1 N54 AP_I5-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m19 N54 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m2 AI0 N28 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P PS=4.98U
m20 N54 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m21 AP_I5-AIN21 AI0 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m22 AP_I5-AIN21 AI0 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m23 N48 AI1 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m24 N48 AI1 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m25 N49 VSS VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m26 N49 VSS VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m27 N83 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m28 N82 N48 N83 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m29 AP_I5-AIND1 AP_I5-AIN21 N82 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m3 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P
+  PS=9.12U
m30 AP_I5-AIND1 N49 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m31 N81 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m32 AP_I5-AIND1 N48 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m33 N80 N48 N81 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m35 AP_I5-AIND1 AP_I5-AIN21 N80 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m36 AP_I5-APN0 N65 AP_I5-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m38 N65 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m39 N65 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m4 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U AD=1.9296P PD=4.98U AS=1.9296P
+  PS=4.98U
m40 AP_I5-AIN20 AI0_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m41 AP_I5-AIN20 AI0_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m42 N87 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m43 N86 N48 N87 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m44 AP_I5-AIND0 AP_I5-AIN20 N86 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m45 AP_I5-AIND0 N49 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m46 N85 N49 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m47 AP_I5-AIND0 N48 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m48 N84 N48 N85 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m5 N28 ACONN0 VDD VDD P L=0.18U W=6.52U AD=3.1296P PD=7.48U AS=3.1296P
+  PS=7.48U
m50 AP_I5-AIND0 AP_I5-AIN20 N84 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m51 AP_I5-APN1 YP0_0 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m52 AP_I5-APN1 YP0_0 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m53 YP0_0 AP_I5-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m54 YP0_0 AP_I5-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U
+  AS=7.2864P PS=16.14U
m55 AP_I5-APN0 YP0_1 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m56 AP_I5-APN0 YP0_1 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m57 YP0_1 AP_I5-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m58 YP0_1 AP_I5-APN0 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U
+  AS=7.2864P PS=16.14U
m59 AP_I6-APN1 N96 AP_I6-AIND1 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m6 N28 ACONN0 VSS VSS N L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P PS=4.16U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m61 N96 AGTPT VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m62 N96 AGTPT VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m63 AP_I6-AIN21 AI0 VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m64 AP_I6-AIN21 AI0 VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m65 N90 AI1_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m66 N90 AI1_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m67 N91 VSS VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P PS=6.9U
m68 N91 VSS VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P PS=3.83U
m69 N125 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m70 N124 N90 N125 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m71 AP_I6-AIND1 AP_I6-AIN21 N124 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m72 AP_I6-AIND1 N91 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m73 N123 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m74 AP_I6-AIND1 N90 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m75 N122 N90 N123 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m77 AP_I6-AIND1 AP_I6-AIN21 N122 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m78 AP_I6-APN0 N107 AP_I6-AIND0 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m80 N107 AGTPB VDD VDD P L=0.18U W=1.48U AD=0.7104P PD=2.44U AS=0.7104P
+  PS=2.44U
m81 N107 AGTPB VSS VSS N L=0.18U W=0.94U AD=0.4512P PD=1.9U AS=0.4512P PS=1.9U
m82 AP_I6-AIN20 AI0_ VDD VDD P L=0.18U W=5.94U AD=2.8512P PD=6.9U AS=2.8512P
+  PS=6.9U
m83 AP_I6-AIN20 AI0_ VSS VSS N L=0.18U W=2.87U AD=1.3776P PD=3.83U AS=1.3776P
+  PS=3.83U
m84 N129 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m85 N128 N90 N129 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m86 AP_I6-AIND0 AP_I6-AIN20 N128 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m87 AP_I6-AIND0 N91 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m88 N127 N91 VSS VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m89 AP_I6-AIND0 N90 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U AS=5.1168P
+  PS=11.62U
m9 AI1 N37 VDD VDD P L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P PS=9.12U
m90 N126 N90 N127 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U AS=2.9952P PS=7.2U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.18U W=10.66U AD=5.1168P PD=11.62U
+  AS=5.1168P PS=11.62U
m92 AP_I6-AIND0 AP_I6-AIN20 N126 VSS N L=0.18U W=6.24U AD=2.9952P PD=7.2U
+  AS=2.9952P PS=7.2U
m93 AP_I6-APN1 YP0_2 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m94 AP_I6-APN1 YP0_2 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m95 YP0_2 AP_I6-APN1 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
m96 YP0_2 AP_I6-APN1 VSS VSS N L=0.18U W=15.18U AD=7.2864P PD=16.14U
+  AS=7.2864P PS=16.14U
m97 AP_I6-APN0 YP0_3 VDD VDD P L=0.27U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m98 AP_I6-APN0 YP0_3 VSS VSS N L=0.54U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m99 YP0_3 AP_I6-APN0 VDD VDD P L=0.18U W=28.56U AD=13.7088P PD=29.52U
+  AS=13.7088P PS=29.52U
.ENDS RA1SHD_2048x32M8HYP24
****
.SUBCKT RA1SHD_2048x32M8HYP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0
+  YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SHD_2048x32M8HYP24X: 100 flat devices **
XI0_0 A0 A1 A0 A1 AGTPB AGTPT VSS VSS AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VDD RA1SHD_2048x32M8HYP24
.ENDS RA1SHD_2048x32M8HYP24X
****
.SUBCKT RA1SHD_2048x32M8HYP12XR A0 ACONN0 AGTP AMX0 AY0 AY0_ BWEN CLK GSRCN
+  GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8HYP12XR: 92 flat devices **
d7 VSS A0 DN 0.2304P 1.92U
d8 VSS BWEN DN 0.2304P 1.92U
m1 N24 N27 VDD VDD P L=0.18U W=8.16U
m10 AP0-APN1 AGTP AP0-AIND1 VDD P L=0.18U W=10.66U
m11 N44 AGTP VDD VDD P L=0.18U W=1.48U
m12 N44 AGTP VSS VSS N L=0.18U W=0.94U
m13 AP0-AIN21 N24 VDD VDD P L=0.18U W=5.94U
m14 AP0-AIN21 N24 VSS VSS N L=0.18U W=2.87U
m15 N38 VSS VDD VDD P L=0.18U W=5.94U
m16 N38 VSS VSS VSS N L=0.18U W=2.87U
m17 N39 VSS VDD VDD P L=0.18U W=5.94U
m18 N39 VSS VSS VSS N L=0.18U W=2.87U
m19 N73 N39 VSS VSS N L=0.18U W=6.24U
m2 N24 N27 VSS VSS N L=0.18U W=4.02U
m20 N72 N38 N73 VSS N L=0.18U W=6.24U
m21 AP0-AIND1 AP0-AIN21 N72 VSS N L=0.18U W=6.24U
m22 AP0-AIND1 N39 VDD VDD P L=0.18U W=10.66U
m23 N71 N39 VSS VSS N L=0.18U W=6.24U
m24 AP0-AIND1 N38 VDD VDD P L=0.18U W=10.66U
m25 N70 N38 N71 VSS N L=0.18U W=6.24U
m26 AP0-AIND1 AP0-AIN21 VDD VDD P L=0.18U W=10.66U
m27 AP0-AIND1 AP0-AIN21 N70 VSS N L=0.18U W=6.24U
m28 AP0-APN0 N55 AP0-AIND0 VSS N L=0.18U W=6.24U
m29 AP0-APN0 AGTP AP0-AIND0 VDD P L=0.18U W=10.66U
m3 N23 ACONN0 VDD VDD P L=0.18U W=8.16U
m30 N55 AGTP VDD VDD P L=0.18U W=1.48U
m31 N55 AGTP VSS VSS N L=0.18U W=0.94U
m32 AP0-AIN20 N23 VDD VDD P L=0.18U W=5.94U
m33 AP0-AIN20 N23 VSS VSS N L=0.18U W=2.87U
m34 N77 N39 VSS VSS N L=0.18U W=6.24U
m35 N76 N38 N77 VSS N L=0.18U W=6.24U
m36 AP0-AIND0 AP0-AIN20 N76 VSS N L=0.18U W=6.24U
m37 AP0-AIND0 N39 VDD VDD P L=0.18U W=10.66U
m38 N75 N39 VSS VSS N L=0.18U W=6.24U
m39 AP0-AIND0 N38 VDD VDD P L=0.18U W=10.66U
m4 N23 ACONN0 VSS VSS N L=0.18U W=4.02U
m40 N74 N38 N75 VSS N L=0.18U W=6.24U
m41 AP0-AIND0 AP0-AIN20 VDD VDD P L=0.18U W=10.66U
m42 AP0-AIND0 AP0-AIN20 N74 VSS N L=0.18U W=6.24U
m43 AP0-APN1 AY0_ VDD VDD P L=0.27U W=0.22U
m44 AP0-APN1 AY0_ VSS VSS N L=0.54U W=0.22U
m45 AY0_ AP0-APN1 VDD VDD P L=0.18U W=28.56U
m46 AY0_ AP0-APN1 VSS VSS N L=0.18U W=15.18U
m47 AP0-APN0 AY0 VDD VDD P L=0.27U W=0.22U
m48 AP0-APN0 AY0 VSS VSS N L=0.54U W=0.22U
m49 AY0 AP0-APN0 VDD VDD P L=0.18U W=28.56U
m5 N27 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AY0 AP0-APN0 VSS VSS N L=0.18U W=15.18U
m51 AP_I1-APN1 N86 AP_I1-AIND1 VSS N L=0.18U W=6.24U
m52 AP_I1-APN1 AGTP AP_I1-AIND1 VDD P L=0.18U W=10.66U
m53 N86 AGTP VDD VDD P L=0.18U W=1.48U
m54 N86 AGTP VSS VSS N L=0.18U W=0.94U
m55 AP_I1-AIN21 N24 VDD VDD P L=0.18U W=5.94U
m56 AP_I1-AIN21 N24 VSS VSS N L=0.18U W=2.87U
m57 N80 VSS VDD VDD P L=0.18U W=5.94U
m58 N80 VSS VSS VSS N L=0.18U W=2.87U
m59 N81 VSS VDD VDD P L=0.18U W=5.94U
m6 N27 ACONN0 VSS VSS N L=0.18U W=3.2U
m60 N81 VSS VSS VSS N L=0.18U W=2.87U
m61 N115 N81 VSS VSS N L=0.18U W=6.24U
m62 N114 N80 N115 VSS N L=0.18U W=6.24U
m63 AP_I1-AIND1 AP_I1-AIN21 N114 VSS N L=0.18U W=6.24U
m64 AP_I1-AIND1 N81 VDD VDD P L=0.18U W=10.66U
m65 N113 N81 VSS VSS N L=0.18U W=6.24U
m66 AP_I1-AIND1 N80 VDD VDD P L=0.18U W=10.66U
m67 N112 N80 N113 VSS N L=0.18U W=6.24U
m68 AP_I1-AIND1 AP_I1-AIN21 VDD VDD P L=0.18U W=10.66U
m69 AP_I1-AIND1 AP_I1-AIN21 N112 VSS N L=0.18U W=6.24U
m70 AP_I1-APN0 N97 AP_I1-AIND0 VSS N L=0.18U W=6.24U
m71 AP_I1-APN0 AGTP AP_I1-AIND0 VDD P L=0.18U W=10.66U
m72 N97 AGTP VDD VDD P L=0.18U W=1.48U
m73 N97 AGTP VSS VSS N L=0.18U W=0.94U
m74 AP_I1-AIN20 N23 VDD VDD P L=0.18U W=5.94U
m75 AP_I1-AIN20 N23 VSS VSS N L=0.18U W=2.87U
m76 N119 N81 VSS VSS N L=0.18U W=6.24U
m77 N118 N80 N119 VSS N L=0.18U W=6.24U
m78 AP_I1-AIND0 AP_I1-AIN20 N118 VSS N L=0.18U W=6.24U
m79 AP_I1-AIND0 N81 VDD VDD P L=0.18U W=10.66U
m80 N117 N81 VSS VSS N L=0.18U W=6.24U
m81 AP_I1-AIND0 N80 VDD VDD P L=0.18U W=10.66U
m82 N116 N80 N117 VSS N L=0.18U W=6.24U
m83 AP_I1-AIND0 AP_I1-AIN20 VDD VDD P L=0.18U W=10.66U
m84 AP_I1-AIND0 AP_I1-AIN20 N116 VSS N L=0.18U W=6.24U
m85 AP_I1-APN1 AY0_ VDD VDD P L=0.27U W=0.22U
m86 AP_I1-APN1 AY0_ VSS VSS N L=0.54U W=0.22U
m87 AY0_ AP_I1-APN1 VDD VDD P L=0.18U W=28.56U
m88 AY0_ AP_I1-APN1 VSS VSS N L=0.18U W=15.18U
m89 AP_I1-APN0 AY0 VDD VDD P L=0.27U W=0.22U
m9 AP0-APN1 N44 AP0-AIND1 VSS N L=0.18U W=6.24U
m90 AP_I1-APN0 AY0 VSS VSS N L=0.54U W=0.22U
m91 AY0 AP_I1-APN0 VDD VDD P L=0.18U W=28.56U
m92 AY0 AP_I1-APN0 VSS VSS N L=0.18U W=15.18U
.ENDS RA1SHD_2048x32M8HYP12XR
****
.SUBCKT RA1SHD_2048x32M8HYP12XRX A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST
+  WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8HYP12XRX: 92 flat devices **
XI0_0 A0 A0 AGTP VSS AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8HYP12XR
.ENDS RA1SHD_2048x32M8HYP12XRX
****
.SUBCKT RA1SHD_2048x32M8Y_DECODE A0_0 A0_1 A1 AGTP AY0 AY0_ BWEN CLK GSRCN
+  GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SHD_2048x32M8Y_DECODE: 192 flat devices **
XI0_0 A0_0 A1 AGTP AGTP AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  RA1SHD_2048x32M8HYP24X
XI1_0 A0_1 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8HYP12XRX
.ENDS RA1SHD_2048x32M8Y_DECODE
****
.SUBCKT RA1SHD_2048x32M8HBF8 CEMX CEN CENI_ CEN_ CLK GSRCN GTP GTPN MBL OEI_
+  OEMX OEN OENI_ OEN_ RST STOV STUBWE TMS WE WEI WEMX WEN WENI_ WEN_ VSS VDD
** RA1SHD_2048x32M8HBF8: 75 flat devices **
d70 VSS WEN DN 0.3364P 2.32U
d71 VSS OEN DN 0.3364P 2.32U
d72 VSS CEN DN 0.3364P 2.32U
d73 VSS STOV DN 0.3364P 2.32U
d74 VSS CLK DN 0.3364P 2.32U
d75 VSS TMS DN 0.3364P 2.32U
m1 WE N44 VDD VDD P L=0.18U W=13.8U AD=6.624P PD=14.76U AS=6.624P PS=14.76U
m10 BF-CLKN CLK VSS VSS N L=0.36U W=1.44U AD=0.6912P PD=2.4U AS=0.6912P
+  PS=2.4U
m11 N99 BF-TMS_ VSS VSS N L=0.18U W=2.3U AD=1.104P PD=3.26U AS=1.104P PS=3.26U
m12 N44 WENI_ N99 VSS N L=0.18U W=2.3U AD=1.104P PD=3.26U AS=1.104P PS=3.26U
m13 N44 BF-TMS_ VDD VDD P L=0.18U W=6.12U AD=2.9376P PD=7.08U AS=2.9376P
+  PS=7.08U
m14 N98 BF-TMS_ VSS VSS N L=0.18U W=2.3U AD=1.104P PD=3.26U AS=1.104P PS=3.26U
m15 N44 WENI_ VDD VDD P L=0.18U W=6.12U AD=2.9376P PD=7.08U AS=2.9376P
+  PS=7.08U
m16 N44 WENI_ N98 VSS N L=0.18U W=2.3U AD=1.104P PD=3.26U AS=1.104P PS=3.26U
m17 BF-TMS_ TMS VDD VDD P L=0.18U W=2.95U AD=1.416P PD=3.91U AS=1.416P
+  PS=3.91U
m18 BF-TMS_ TMS VSS VSS N L=0.18U W=1.52U AD=0.7296P PD=2.48U AS=0.7296P
+  PS=2.48U
m19 OEI_ N57 VDD VDD P L=0.18U W=15.88U AD=7.6224P PD=16.84U AS=7.6224P
+  PS=16.84U
m2 WE N44 VSS VSS N L=0.18U W=7.11U AD=3.4128P PD=8.07U AS=3.4128P PS=8.07U
m20 OEI_ N57 VSS VSS N L=0.18U W=8.16U AD=3.9168P PD=9.12U AS=3.9168P PS=9.12U
m21 N57 N60 VDD VDD P L=0.18U W=5.86U AD=2.8128P PD=6.82U AS=2.8128P PS=6.82U
m22 N57 N60 VSS VSS N L=0.18U W=3U AD=1.44P PD=3.96U AS=1.44P PS=3.96U
m23 N60 BF-TMS_ VDD VDD P L=0.18U W=2.27U AD=1.0896P PD=3.23U AS=1.0896P
+  PS=3.23U
m24 N100 BF-TMS_ VSS VSS N L=0.18U W=2.22U AD=1.0656P PD=3.18U AS=1.0656P
+  PS=3.18U
m25 N60 OENI_ VDD VDD P L=0.18U W=2.27U AD=1.0896P PD=3.23U AS=1.0896P
+  PS=3.23U
m26 N60 OENI_ N100 VSS N L=0.18U W=2.22U AD=1.0656P PD=3.18U AS=1.0656P
+  PS=3.18U
m27 N102 GTP VSS VSS N L=0.18U W=2.65U AD=1.272P PD=3.61U AS=1.272P PS=3.61U
m28 BF-RSRCN BF-CKSTOV N102 VSS N L=0.18U W=2.65U AD=1.272P PD=3.61U AS=1.272P
+  PS=3.61U
m29 BF-RSRCN GTP VDD VDD P L=0.18U W=5.7U AD=2.736P PD=6.66U AS=2.736P
+  PS=6.66U
m3 BF-CENMML BF-CLKN N97 VDD P L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m30 N101 GTP VSS VSS N L=0.18U W=2.65U AD=1.272P PD=3.61U AS=1.272P PS=3.61U
m31 BF-RSRCN BF-CKSTOV VDD VDD P L=0.18U W=5.7U AD=2.736P PD=6.66U AS=2.736P
+  PS=6.66U
m32 BF-RSRCN BF-CKSTOV N101 VSS N L=0.18U W=2.65U AD=1.272P PD=3.61U AS=1.272P
+  PS=3.61U
m33 BF-RSTSRC BF-RSRCN VDD VDD P L=0.18U W=14.16U AD=6.7968P PD=15.12U
+  AS=6.7968P PS=15.12U
m34 BF-RSTSRC BF-RSRCN VSS VSS N L=0.18U W=6.63U AD=3.1824P PD=7.59U
+  AS=3.1824P PS=7.59U
m35 BF-CKSTOV STOV VDD VDD P L=0.18U W=2.68U AD=1.2864P PD=3.64U AS=1.2864P
+  PS=3.64U
m36 N103 STOV VSS VSS N L=0.18U W=2.5U AD=1.2P PD=3.46U AS=1.2P PS=3.46U
m37 BF-CKSTOV CLK VDD VDD P L=0.18U W=2.68U AD=1.2864P PD=3.64U AS=1.2864P
+  PS=3.64U
m38 BF-CKSTOV CLK N103 VSS N L=0.18U W=2.5U AD=1.2P PD=3.46U AS=1.2P PS=3.46U
m39 GTPN BF-GTPI N71 VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m4 N97 BF-CEL VDD VDD P L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m40 N37 N37 VDD VDD P L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m41 GTPN BF-GTPI VDD VDD P L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m42 N37 VDD VDD VDD P L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m43 BF-GTPI GTPN VDD VDD P L=0.18U W=0.44U AD=0.2112P PD=1.4U AS=0.2112P
+  PS=1.4U
m44 BF-GTPI GTPN VSS VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m45 N71 N37 VSS VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m46 N105 BF-CLKN VSS VSS N L=0.18U W=3.35U AD=1.608P PD=4.31U AS=1.608P
+  PS=4.31U
m47 GSRCN BF-CEL N105 VSS N L=0.18U W=3.35U AD=1.608P PD=4.31U AS=1.608P
+  PS=4.31U
m48 GSRCN BF-CLKN VDD VDD P L=0.18U W=5.72U AD=2.7456P PD=6.68U AS=2.7456P
+  PS=6.68U
m49 N104 BF-CLKN VSS VSS N L=0.18U W=3.35U AD=1.608P PD=4.31U AS=1.608P
+  PS=4.31U
m5 BF-CENMML CLK N96 VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m50 GSRCN BF-CEL VDD VDD P L=0.18U W=5.72U AD=2.7456P PD=6.68U AS=2.7456P
+  PS=6.68U
m51 GSRCN BF-CEL N104 VSS N L=0.18U W=3.35U AD=1.608P PD=4.31U AS=1.608P
+  PS=4.31U
m52 N80 BF-CLKN VSS VSS N L=0.18U W=0.86U AD=0.4128P PD=1.82U AS=0.4128P
+  PS=1.82U
m53 N82 CLK VDD VDD P L=0.18U W=2.17U AD=1.0416P PD=3.13U AS=1.0416P PS=3.13U
m54 BF-CENMML CENI_ N84 VDD P L=0.18U W=2.17U AD=1.0416P PD=3.13U AS=1.0416P
+  PS=3.13U
m55 BF-CENMML CENI_ N80 VSS N L=0.18U W=0.86U AD=0.4128P PD=1.82U AS=0.4128P
+  PS=1.82U
m56 N84 TMS N82 VDD P L=0.18U W=2.17U AD=1.0416P PD=3.13U AS=1.0416P PS=3.13U
m57 BF-CENMML TMS N80 VSS N L=0.18U W=0.86U AD=0.4128P PD=1.82U AS=0.4128P
+  PS=1.82U
m58 RST BF-MBLN VDD VDD P L=0.18U W=3.3U AD=1.584P PD=4.26U AS=1.584P PS=4.26U
m59 RST BF-RSTSRC VDD VDD P L=0.18U W=22.5U AD=10.8P PD=23.46U AS=10.8P
+  PS=23.46U
m6 N96 BF-CEL VSS VSS N L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m60 BF-MBLN MBL VDD VDD P L=0.18U W=9.15U AD=4.392P PD=10.11U AS=4.392P
+  PS=10.11U
m61 BF-MBLN MBL VSS VSS N L=0.18U W=3.05U AD=0.732P PD=0.48U AS=1.464P
+  PS=4.01U
m62 WEN_ WEN VDD VDD P L=0.18U W=3.2U AD=1.536P PD=4.16U AS=1.536P PS=4.16U
m63 WEN_ WEN VSS VSS N L=0.18U W=1.54U AD=0.7392P PD=2.5U AS=0.7392P PS=2.5U
m64 OEN_ OEN VDD VDD P L=0.18U W=1.21U AD=0.5808P PD=2.17U AS=0.5808P PS=2.17U
m65 OEN_ OEN VSS VSS N L=0.18U W=0.59U AD=0.2832P PD=1.55U AS=0.2832P PS=1.55U
m66 CEN_ CEN VDD VDD P L=0.18U W=2.6U AD=1.248P PD=3.56U AS=1.248P PS=3.56U
m67 CEN_ CEN VSS VSS N L=0.18U W=1.28U AD=0.6144P PD=2.24U AS=0.6144P PS=2.24U
m68 RST BF-MBLN N95 VSS N L=0.18U W=27.4U AD=13.152P PD=28.36U AS=13.152P
+  PS=28.36U
m69 N95 BF-RSTSRC VSS VSS N L=0.18U W=35.4U AD=16.992P PD=36.36U AS=16.992P
+  PS=36.36U
m7 BF-CEL BF-CENMML VDD VDD P L=0.18U W=2.63U AD=1.2624P PD=3.59U AS=1.2624P
+  PS=3.59U
m8 BF-CEL BF-CENMML VSS VSS N L=0.18U W=1.37U AD=0.6576P PD=2.33U AS=0.6576P
+  PS=2.33U
m9 BF-CLKN CLK VDD VDD P L=0.18U W=3.07U AD=1.4736P PD=4.03U AS=1.4736P
+  PS=4.03U
.ENDS RA1SHD_2048x32M8HBF8
****
.SUBCKT RA1SHD_2048x32M8HBFX CEN CEN_ CLK GSRCN GTP GTPN MBL OEI_ OEN OEN_ RST
+  STUBWE WE WEI WEN_ VSS VDD
** RA1SHD_2048x32M8HBFX: 75 flat devices **
XI0_0 VSS CEN CEN_ CEN_ CLK GSRCN GTP GTPN MBL OEI_ VSS OEN OEN_ OEN_ RST VSS
+  STUBWE VSS WE WEI VSS VSS WEN_ WEN_ VSS VDD RA1SHD_2048x32M8HBF8
.ENDS RA1SHD_2048x32M8HBFX
****
.SUBCKT RA1SHD_2048x32M8CCMWP BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** RA1SHD_2048x32M8CCMWP: 12 flat devices **
m1 BL MWPT N8 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m10 N14 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m11 N16 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m12 N18 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m2 BL_ MWPT N9 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m3 BL MWPB N10 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m4 BL_ MWPB N11 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m5 N8 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m6 N9 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m7 N10 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m8 N11 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m9 N12 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P PS=1.175U
.ENDS RA1SHD_2048x32M8CCMWP
****
.SUBCKT RA1SHD_2048x32M8CCMWG BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** RA1SHD_2048x32M8CCMWG: 12 flat devices **
m1 BL MWPT N8 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m10 N14 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m11 N16 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m12 N18 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m2 BL_ MWPT N9 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m3 BL MWPB N10 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m4 BL_ MWPB N11 VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
m5 N8 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m6 N9 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m7 N10 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m8 N11 VSS VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P PS=1.23U
m9 N12 VSS VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P PS=1.175U
.ENDS RA1SHD_2048x32M8CCMWG
****
.SUBCKT RA1SHD_2048x32M8FLMWG BL0 BL0_ BL1 BL1_ MWL WP0 WP1 WP2 WP3 VSS VDD
** RA1SHD_2048x32M8FLMWG: 24 flat devices **
M0 NET071 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P7
M1 NET068 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P6
M10 BL1_ WP3 NET124 VSS N W=0.22U L=0.265U M=1 $name=/N18
M11 NET106 WP0 BL0 VSS N W=0.22U L=0.265U M=1 $name=/N19
M12 NET109 WP3 BL1 VSS N W=0.22U L=0.265U M=1 $name=/N17
M13 BL0_ WP3 NET139 VSS N W=0.22U L=0.265U M=1 $name=/N16
M14 NET115 VSS VSS VSS N W=0.27U L=0.18U M=1 $name=/N9
M15 VSS VSS NET106 VSS N W=0.27U L=0.18U M=1 $name=/N8
M16 VSS VSS NET109 VSS N W=0.27U L=0.18U M=1 $name=/N7
M17 NET124 VSS VSS VSS N W=0.27U L=0.18U M=1 $name=/N6
M18 NET127 WP2 BL1 VSS N W=0.22U L=0.265U M=1 $name=/N21
M19 BL0_ WP2 NET115 VSS N W=0.22U L=0.265U M=1 $name=/N20
M2 NET054 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P5
M20 BL1_ WP2 NET100 VSS N W=0.22U L=0.265U M=1 $name=/N22
M21 NET136 WP1 BL0 VSS N W=0.22U L=0.265U M=1 $name=/N2
M22 NET139 VSS VSS VSS N W=0.27U L=0.18U M=1 $name=/N1
M23 VSS VSS NET136 VSS N W=0.27U L=0.18U M=1 $name=/N0
M3 NET82 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P4
M4 NET083 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P3
M5 NET87 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P2
M6 NET053 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P1
M7 NET94 VSS VDD VDD P W=0.215U L=0.2U M=1 $name=/P0
M8 VSS VSS NET127 VSS N W=0.27U L=0.18U M=1 $name=/N15
M9 NET100 VSS VSS VSS N W=0.27U L=0.18U M=1 $name=/N14
.ENDS RA1SHD_2048x32M8FLMWG
****
.SUBCKT RA1SHD_2048x32M8MODEL_ROW_16 BL0 BL0_ BL1 BL1_ BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16
+  BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40
+  BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52
+  BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64
+  BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76
+  BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88
+  BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100
+  BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110
+  BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120
+  BL_121 BL_122 BL_123 BL_124 BL_125 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 MWLB VSS VDD
** RA1SHD_2048x32M8MODEL_ROW_16: 1548 flat devices **
XI0_0 BL_0 BL__0 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI100_0 BL_95 BL__95 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI101_0 BL_96 BL__96 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI102_0 BL_97 BL__97 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI103_0 BL_98 BL__98 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI104_0 BL_99 BL__99 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI105_0 BL_100 BL__100 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI106_0 BL_101 BL__101 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI107_0 BL_102 BL__102 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI108_0 BL_103 BL__103 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI109_0 BL_104 BL__104 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI10_0 BL_10 BL__10 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI110_0 BL_105 BL__105 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI111_0 BL_106 BL__106 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI112_0 BL_107 BL__107 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI113_0 BL_108 BL__108 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI114_0 BL_109 BL__109 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI115_0 BL_110 BL__110 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI116_0 BL_111 BL__111 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI117_0 BL_112 BL__112 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI118_0 BL_113 BL__113 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI119_0 BL_114 BL__114 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI11_0 BL_11 BL__11 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI120_0 BL_115 BL__115 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI121_0 BL_116 BL__116 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI122_0 BL_117 BL__117 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI123_0 BL_118 BL__118 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI124_0 BL_119 BL__119 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI125_0 BL_120 BL__120 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI126_0 BL_121 BL__121 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI127_0 BL_122 BL__122 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI128_0 BL_123 BL__123 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI129_0 BL_124 BL__124 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI12_0 BL_12 BL__12 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI130_0 BL_125 BL__125 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI13_0 BL_13 BL__13 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI14_0 BL_14 BL__14 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI15_0 BL_15 BL__15 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI16_0 BL_16 BL__16 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI17_0 BL_17 BL__17 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI18_0 BL_18 BL__18 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI19_0 BL_19 BL__19 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI1_0 BL_1 BL__1 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI20_0 BL_20 BL__20 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI21_0 BL_21 BL__21 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI22_0 BL_22 BL__22 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI23_0 BL_23 BL__23 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI24_0 BL_24 BL__24 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI25_0 BL_25 BL__25 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI26_0 BL_26 BL__26 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI27_0 BL_27 BL__27 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI28_0 BL_28 BL__28 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI29_0 BL_29 BL__29 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI2_0 BL_2 BL__2 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI30_0 BL_30 BL__30 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI31_0 BL_31 BL__31 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI32_0 MWLB MWLB VSS VDD RA1SHD_2048x32M8FLMWSTRAP
XI33_0 BL_32 BL__32 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI34_0 BL_33 BL__33 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI35_0 BL_34 BL__34 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI36_0 BL_35 BL__35 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI37_0 BL_36 BL__36 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI38_0 BL_37 BL__37 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI39_0 BL_38 BL__38 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI3_0 BL_3 BL__3 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI40_0 BL_39 BL__39 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI41_0 BL_40 BL__40 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI42_0 BL_41 BL__41 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI43_0 BL_42 BL__42 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI44_0 BL_43 BL__43 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI45_0 BL_44 BL__44 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI46_0 BL_45 BL__45 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI47_0 BL_46 BL__46 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI48_0 BL_47 BL__47 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI49_0 BL_48 BL__48 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI4_0 BL_4 BL__4 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI50_0 BL_49 BL__49 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI51_0 BL_50 BL__50 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI52_0 BL_51 BL__51 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI53_0 BL_52 BL__52 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI54_0 BL_53 BL__53 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI55_0 BL_54 BL__54 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI56_0 BL_55 BL__55 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI57_0 BL_56 BL__56 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI58_0 BL_57 BL__57 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI59_0 BL_58 BL__58 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI5_0 BL_5 BL__5 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI60_0 BL_59 BL__59 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI61_0 BL_60 BL__60 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI62_0 BL_61 BL__61 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI63_0 BL_62 BL__62 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI64_0 BL_63 BL__63 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI65_0 MWLB MWLB VSS VDD RA1SHD_2048x32M8FLMWSTRAP
XI66_0 BL0 BL0_ BL1 BL1_ MWLB MWLB MWLB VSS VSS VSS VDD RA1SHD_2048x32M8FLMWG
XI68_0 BL_64 BL__64 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI69_0 BL_65 BL__65 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI6_0 BL_6 BL__6 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
XI70_0 BL_66 BL__66 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI71_0 BL_67 BL__67 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI72_0 BL_68 BL__68 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI73_0 BL_69 BL__69 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI74_0 BL_70 BL__70 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI75_0 BL_71 BL__71 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI76_0 BL_72 BL__72 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI77_0 BL_73 BL__73 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI78_0 BL_74 BL__74 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI79_0 BL_75 BL__75 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI7_0 BL_7 BL__7 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI80_0 BL_76 BL__76 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI81_0 BL_77 BL__77 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI82_0 BL_78 BL__78 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI83_0 BL_79 BL__79 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI84_0 BL_80 BL__80 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI85_0 BL_81 BL__81 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI86_0 BL_82 BL__82 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI87_0 BL_83 BL__83 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI88_0 BL_84 BL__84 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI89_0 BL_85 BL__85 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI8_0 BL_8 BL__8 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWG
XI90_0 BL_86 BL__86 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI91_0 BL_87 BL__87 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI92_0 BL_88 BL__88 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI93_0 BL_89 BL__89 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI94_0 BL_90 BL__90 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI95_0 BL_91 BL__91 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI96_0 BL_92 BL__92 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWP
XI97_0 BL_93 BL__93 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI98_0 VSS VSS VSS VDD RA1SHD_2048x32M8FLMWSTRAP
XI99_0 BL_94 BL__94 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CCMWG
XI9_0 BL_9 BL__9 MWLB MWLB MWLB MWLB VSS VDD RA1SHD_2048x32M8CCMWP
.ENDS RA1SHD_2048x32M8MODEL_ROW_16
****
.SUBCKT RA1SHD_2048x32M8WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8WD: 30 flat devices **
m1 N25 RSWN0 GTP VDD P L=0.18U W=1.54U AD=0.74112P PD=2.504U AS=0.37056P
+  PS=0.48U
m10 WL0 WL0_EN_ VSS VSS N L=0.18U W=10U AD=4.8P PD=10.96U AS=4.8P PS=10.96U
m11 N24 RSWN1 GTP VDD P L=0.18U W=1.54U AD=0.74112P PD=2.504U AS=0.37056P
+  PS=0.48U
m12 N24 WLI1 GTP VSS N L=0.18U W=1.54U AD=0.74112P PD=2.504U AS=0.37056P
+  PS=0.48U
m13 N33 G0 VSS VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m14 N34 G1 N33 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m15 RSWN1 G2_W1 N34 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P
+  PS=0.48U
m16 RSWN1 G0 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m17 RSWN1 G2_W1 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m18 RSWN1 G1 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m19 WL1 WL1_EN_ VDD VDD P L=0.18U W=24.56U AD=11.7912P PD=25.525U AS=11.7912P
+  PS=25.525U
m2 N25 WLI0 GTP VSS N L=0.18U W=1.54U AD=0.74112P PD=2.504U AS=0.37056P
+  PS=0.48U
m20 WL1 WL1_EN_ VSS VSS N L=0.18U W=10U AD=4.8P PD=10.96U AS=4.8P PS=10.96U
m21 WLI1 RSWN1 VDD VDD P L=0.18U W=0.3U AD=0.14496P PD=1.262U AS=0.14496P
+  PS=1.262U
m22 WLI1 RSWN1 VSS VSS N L=0.18U W=0.22U AD=0.10608P PD=1.181U AS=0.10608P
+  PS=1.181U
m23 WLI0 RSWN0 VDD VDD P L=0.18U W=0.3U AD=0.14496P PD=1.262U AS=0.14496P
+  PS=1.262U
m24 WLI0 RSWN0 VSS VSS N L=0.18U W=0.22U AD=0.10608P PD=1.181U AS=0.10608P
+  PS=1.181U
m25 N24 RSWN1 VSS VSS N L=0.18U W=1U AD=0.48P PD=1.96U AS=0.48P PS=1.96U
m26 N25 RSWN0 VSS VSS N L=0.18U W=1U AD=0.48P PD=1.96U AS=0.48P PS=1.96U
m27 WL1_EN_ N24 VDD VDD P L=0.18U W=8.92U AD=4.28304P PD=9.883U AS=4.28304P
+  PS=9.883U
m28 WL1_EN_ N24 VSS VSS N L=0.18U W=4.5U AD=2.16P PD=5.46U AS=2.16P PS=5.46U
m29 WL0_EN_ N25 VDD VDD P L=0.18U W=8.92U AD=4.28304P PD=9.883U AS=4.28304P
+  PS=9.883U
m3 N26 G0 VSS VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m30 WL0_EN_ N25 VSS VSS N L=0.18U W=4.5U AD=2.16P PD=5.46U AS=2.16P PS=5.46U
m4 N27 G1 N26 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m5 RSWN0 G2_W0 N27 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P
+  PS=0.48U
m6 RSWN0 G0 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P PS=1.316U
m7 RSWN0 G2_W0 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m8 RSWN0 G1 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P PS=1.316U
m9 WL0 WL0_EN_ VDD VDD P L=0.18U W=24.56U AD=11.7912P PD=25.525U AS=11.7912P
+  PS=25.525U
.ENDS RA1SHD_2048x32M8WD
****
.SUBCKT RA1SHD_2048x32M8WD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8WD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8WD
.ENDS RA1SHD_2048x32M8WD3
****
.SUBCKT RA1SHD_2048x32M8ROW_FILLER3 G0 G1 GTP WL0 WL1 XP0F XP0_0 XP0_1 XP0_2
+  XP0_3 XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8ROW_FILLER3: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD_2048x32M8WD3
.ENDS RA1SHD_2048x32M8ROW_FILLER3
****
.SUBCKT RA1SHD_2048x32M8WD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8WD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8WD
.ENDS RA1SHD_2048x32M8WD0
****
.SUBCKT RA1SHD_2048x32M8ROW_8 G0 G1 G1B GTP WL0 WL1 XP0F_0 XP0F_1 XP0F_2
+  XP0F_3 XP0_0 XP0_1 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1_0 XP1_1 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8ROW_8: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD_2048x32M8WD0
.ENDS RA1SHD_2048x32M8ROW_8
****
.SUBCKT RA1SHD_2048x32M8WD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8WD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8WD
.ENDS RA1SHD_2048x32M8WD1
****
.SUBCKT RA1SHD_2048x32M8ROW_FILLER1 G0 G1 GTP WL0 WL1 XP0F XP0_0 XP0_1 XP0_2
+  XP0_3 XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8ROW_FILLER1: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD_2048x32M8WD1
.ENDS RA1SHD_2048x32M8ROW_FILLER1
****
.SUBCKT RA1SHD_2048x32M8WD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8WD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8WD
.ENDS RA1SHD_2048x32M8WD2
****
.SUBCKT RA1SHD_2048x32M8ROW_FILLER2 G0 G1 GTP WL0 WL1 XP0F XP0_0 XP0_1 XP0_2
+  XP0_3 XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8ROW_FILLER2: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD_2048x32M8WD2
.ENDS RA1SHD_2048x32M8ROW_FILLER2
****
.SUBCKT RA1SHD_2048x32M8MWD GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8MWD: 9 flat devices **
m1 MWL N15 VDD VDD P L=0.18U W=30.96U AD=14.8608P PD=31.92U AS=14.8608P
+  PS=31.92U
m2 MWL N15 VSS VSS N L=0.18U W=15.81U AD=7.5888P PD=16.77U AS=7.5888P
+  PS=16.77U
m3 N15 N18 VDD VDD P L=0.18U W=16.5U AD=7.92P PD=17.46U AS=7.92P PS=17.46U
m4 N15 N18 VSS VSS N L=0.18U W=7.74U AD=3.7152P PD=8.7U AS=3.7152P PS=8.7U
m5 MBL GTP VDD VDD P L=0.18U W=15.35U AD=7.368P PD=16.31U AS=7.368P PS=16.31U
m6 MBL_ GTP VDD VDD P L=0.18U W=15.35U AD=7.368P PD=16.31U AS=7.368P PS=16.31U
m7 MBL GTP MBL_ VDD P L=0.18U W=15.35U AD=7.368P PD=16.31U AS=7.368P PS=16.31U
m8 N18 VSS GTP VDD P L=0.35U W=2U AD=0.96P PD=2.96U AS=0.96P PS=2.96U
m9 N18 VDD GTP VSS N L=0.35U W=2U AD=0.96P PD=2.96U AS=0.96P PS=2.96U
.ENDS RA1SHD_2048x32M8MWD
****
.SUBCKT RA1SHD_2048x32M8ROW_TOP G0F G1F GTP MBL MBL_ MWL XP0F XP0_0 XP0_1
+  XP0_2 XP0_3 XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8ROW_TOP: 9 flat devices **
XI6_0 GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SHD_2048x32M8MWD
.ENDS RA1SHD_2048x32M8ROW_TOP
****
.SUBCKT RA1SHD_2048x32M8ROW_64 G0 G0B G1 G1B GTP WL0 WL1 XP0F_0 XP0F_1 XP0F_2
+  XP0F_3 XP0F_4 XP0F_5 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1F_4 XP1F_5 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8ROW_64: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD_2048x32M8WD0
.ENDS RA1SHD_2048x32M8ROW_64
****
.SUBCKT RA1SHD_2048x32M8HWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8HWDB: 30 flat devices **
m1 N25 WD_I0-RSWN0 GTP VDD P L=0.18U W=1.54U AD=0.74112P PD=2.504U AS=0.37056P
+  PS=0.48U
m10 WL0 WD_I0-WL0_EN_ VSS VSS N L=0.18U W=10U AD=4.8P PD=10.96U AS=4.8P
+  PS=10.96U
m11 N24 WD_I0-RSWN1 GTP VDD P L=0.18U W=1.54U AD=0.74112P PD=2.504U
+  AS=0.37056P PS=0.48U
m12 N24 WD_I0-WLI1 GTP VSS N L=0.18U W=1.54U AD=0.74112P PD=2.504U AS=0.37056P
+  PS=0.48U
m13 N33 G0 VSS VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m14 N34 G1 N33 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m15 WD_I0-RSWN1 G2_W1 N34 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P
+  PS=0.48U
m16 WD_I0-RSWN1 G0 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m17 WD_I0-RSWN1 G2_W1 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m18 WD_I0-RSWN1 G1 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m19 WL1 WD_I0-WL1_EN_ VDD VDD P L=0.18U W=24.56U AD=11.7912P PD=25.525U
+  AS=11.7912P PS=25.525U
m2 N25 WD_I0-WLI0 GTP VSS N L=0.18U W=1.54U AD=0.74112P PD=2.504U AS=0.37056P
+  PS=0.48U
m20 WL1 WD_I0-WL1_EN_ VSS VSS N L=0.18U W=10U AD=4.8P PD=10.96U AS=4.8P
+  PS=10.96U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD P L=0.18U W=0.3U AD=0.14496P PD=1.262U
+  AS=0.14496P PS=1.262U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS N L=0.18U W=0.22U AD=0.10608P PD=1.181U
+  AS=0.10608P PS=1.181U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD P L=0.18U W=0.3U AD=0.14496P PD=1.262U
+  AS=0.14496P PS=1.262U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS N L=0.18U W=0.22U AD=0.10608P PD=1.181U
+  AS=0.10608P PS=1.181U
m25 N24 WD_I0-RSWN1 VSS VSS N L=0.18U W=1U AD=0.48P PD=1.96U AS=0.48P PS=1.96U
m26 N25 WD_I0-RSWN0 VSS VSS N L=0.18U W=1U AD=0.48P PD=1.96U AS=0.48P PS=1.96U
m27 WD_I0-WL1_EN_ N24 VDD VDD P L=0.18U W=8.92U AD=4.28304P PD=9.883U
+  AS=4.28304P PS=9.883U
m28 WD_I0-WL1_EN_ N24 VSS VSS N L=0.18U W=4.5U AD=2.16P PD=5.46U AS=2.16P
+  PS=5.46U
m29 WD_I0-WL0_EN_ N25 VDD VDD P L=0.18U W=8.92U AD=4.28304P PD=9.883U
+  AS=4.28304P PS=9.883U
m3 N26 G0 VSS VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m30 WD_I0-WL0_EN_ N25 VSS VSS N L=0.18U W=4.5U AD=2.16P PD=5.46U AS=2.16P
+  PS=5.46U
m4 N27 G1 N26 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P PS=0.48U
m5 WD_I0-RSWN0 G2_W0 N27 VSS N L=0.18U W=0.71U AD=0.1704P PD=0.48U AS=0.1704P
+  PS=0.48U
m6 WD_I0-RSWN0 G0 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m7 WD_I0-RSWN0 G2_W0 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m8 WD_I0-RSWN0 G1 VDD VDD P L=0.18U W=0.36U AD=85.44F PD=0.48U AS=0.17088P
+  PS=1.316U
m9 WL0 WD_I0-WL0_EN_ VDD VDD P L=0.18U W=24.56U AD=11.7912P PD=25.525U
+  AS=11.7912P PS=25.525U
.ENDS RA1SHD_2048x32M8HWDB
****
.SUBCKT RA1SHD_2048x32M8HWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8HWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8HWDB
.ENDS RA1SHD_2048x32M8HWDB0
****
.SUBCKT RA1SHD_2048x32M8ROW_BOTTOM G0 G1 GTP WL0 WL1 XP0F_0 XP0F_1 XP0F_2
+  XP0F_3 XP0F_4 XP0F_5 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1F_4 XP1F_5 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SHD_2048x32M8ROW_BOTTOM: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SHD_2048x32M8HWDB0
.ENDS RA1SHD_2048x32M8ROW_BOTTOM
****
.SUBCKT RA1SHD_2048x32M8WORD_ROWS GTP MBL MBL_ MWL WL0_0 WL0_1 WL0_2 WL0_3
+  WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14
+  WL0_15 WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21 WL0_22 WL0_23 WL0_24
+  WL0_25 WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL0_31 WL0_32 WL0_33 WL0_34
+  WL0_35 WL0_36 WL0_37 WL0_38 WL0_39 WL0_40 WL0_41 WL0_42 WL0_43 WL0_44
+  WL0_45 WL0_46 WL0_47 WL0_48 WL0_49 WL0_50 WL0_51 WL0_52 WL0_53 WL0_54
+  WL0_55 WL0_56 WL0_57 WL0_58 WL0_59 WL0_60 WL0_61 WL0_62 WL0_63 WL0_64
+  WL0_65 WL0_66 WL0_67 WL0_68 WL0_69 WL0_70 WL0_71 WL0_72 WL0_73 WL0_74
+  WL0_75 WL0_76 WL0_77 WL0_78 WL0_79 WL0_80 WL0_81 WL0_82 WL0_83 WL0_84
+  WL0_85 WL0_86 WL0_87 WL0_88 WL0_89 WL0_90 WL0_91 WL0_92 WL0_93 WL0_94
+  WL0_95 WL0_96 WL0_97 WL0_98 WL0_99 WL0_100 WL0_101 WL0_102 WL0_103 WL0_104
+  WL0_105 WL0_106 WL0_107 WL0_108 WL0_109 WL0_110 WL0_111 WL0_112 WL0_113
+  WL0_114 WL0_115 WL0_116 WL0_117 WL0_118 WL0_119 WL0_120 WL0_121 WL0_122
+  WL0_123 WL0_124 WL0_125 WL0_126 WL0_127 WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5
+  WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13 WL1_14 WL1_15 WL1_16
+  WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23 WL1_24 WL1_25 WL1_26
+  WL1_27 WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33 WL1_34 WL1_35 WL1_36
+  WL1_37 WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43 WL1_44 WL1_45 WL1_46
+  WL1_47 WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53 WL1_54 WL1_55 WL1_56
+  WL1_57 WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 WL1_63 WL1_64 WL1_65 WL1_66
+  WL1_67 WL1_68 WL1_69 WL1_70 WL1_71 WL1_72 WL1_73 WL1_74 WL1_75 WL1_76
+  WL1_77 WL1_78 WL1_79 WL1_80 WL1_81 WL1_82 WL1_83 WL1_84 WL1_85 WL1_86
+  WL1_87 WL1_88 WL1_89 WL1_90 WL1_91 WL1_92 WL1_93 WL1_94 WL1_95 WL1_96
+  WL1_97 WL1_98 WL1_99 WL1_100 WL1_101 WL1_102 WL1_103 WL1_104 WL1_105
+  WL1_106 WL1_107 WL1_108 WL1_109 WL1_110 WL1_111 WL1_112 WL1_113 WL1_114
+  WL1_115 WL1_116 WL1_117 WL1_118 WL1_119 WL1_120 WL1_121 WL1_122 WL1_123
+  WL1_124 WL1_125 WL1_126 WL1_127 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP1_0
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD
** RA1SHD_2048x32M8WORD_ROWS: 3849 flat devices **
XI0_0 XP0_1 XP0_5 GTP WL0_0 WL1_0 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP1_0
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_BOTTOM
XI0_1 XP0_1 XP0_5 GTP WL0_1 WL1_1 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_10 XP0_1 XP0_4 GTP WL0_10 WL1_10 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_100 XP1_0 XP1_5 XP0_5 GTP WL0_100 WL1_100 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_101 XP1_0 XP1_5 GTP WL0_101 WL1_101 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_102 XP1_0 XP1_5 GTP WL0_102 WL1_102 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_103 XP1_0 XP1_5 GTP WL0_103 WL1_103 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_104 XP1_0 XP0_4 XP1_5 GTP WL0_104 WL1_104 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_105 XP1_0 XP0_4 GTP WL0_105 WL1_105 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_106 XP1_0 XP0_4 GTP WL0_106 WL1_106 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_107 XP1_0 XP0_4 GTP WL0_107 WL1_107 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_108 XP1_0 XP1_4 XP0_4 GTP WL0_108 WL1_108 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_109 XP1_0 XP1_4 GTP WL0_109 WL1_109 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_11 XP0_1 XP0_4 GTP WL0_11 WL1_11 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_110 XP1_0 XP1_4 GTP WL0_110 WL1_110 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_111 XP1_0 XP1_4 GTP WL0_111 WL1_111 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_112 XP1_0 XP0_3 XP1_4 GTP WL0_112 WL1_112 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_113 XP1_0 XP0_3 GTP WL0_113 WL1_113 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_114 XP1_0 XP0_3 GTP WL0_114 WL1_114 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_115 XP1_0 XP0_3 GTP WL0_115 WL1_115 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_116 XP1_0 XP1_3 XP0_3 GTP WL0_116 WL1_116 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_117 XP1_0 XP1_3 GTP WL0_117 WL1_117 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_118 XP1_0 XP1_3 GTP WL0_118 WL1_118 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_119 XP1_0 XP1_3 GTP WL0_119 WL1_119 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_12 XP0_1 XP1_4 XP0_4 GTP WL0_12 WL1_12 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_120 XP1_0 XP0_2 XP1_3 GTP WL0_120 WL1_120 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_121 XP1_0 XP0_2 GTP WL0_121 WL1_121 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_122 XP1_0 XP0_2 GTP WL0_122 WL1_122 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_123 XP1_0 XP0_2 GTP WL0_123 WL1_123 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_124 XP1_0 XP1_2 XP0_2 GTP WL0_124 WL1_124 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_125 XP1_0 XP1_2 GTP WL0_125 WL1_125 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_126 XP1_0 XP1_2 GTP WL0_126 WL1_126 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_127 XP1_0 XP1_2 GTP WL0_127 WL1_127 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_128 XP1_0 XP1_2 GTP MBL MBL_ MWL XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_TOP
XI0_13 XP0_1 XP1_4 GTP WL0_13 WL1_13 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_14 XP0_1 XP1_4 GTP WL0_14 WL1_14 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_15 XP0_1 XP1_4 GTP WL0_15 WL1_15 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_16 XP0_1 XP0_3 XP1_4 GTP WL0_16 WL1_16 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_17 XP0_1 XP0_3 GTP WL0_17 WL1_17 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_18 XP0_1 XP0_3 GTP WL0_18 WL1_18 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_19 XP0_1 XP0_3 GTP WL0_19 WL1_19 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_2 XP0_1 XP0_5 GTP WL0_2 WL1_2 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_20 XP0_1 XP1_3 XP0_3 GTP WL0_20 WL1_20 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_21 XP0_1 XP1_3 GTP WL0_21 WL1_21 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_22 XP0_1 XP1_3 GTP WL0_22 WL1_22 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_23 XP0_1 XP1_3 GTP WL0_23 WL1_23 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_24 XP0_1 XP0_2 XP1_3 GTP WL0_24 WL1_24 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_25 XP0_1 XP0_2 GTP WL0_25 WL1_25 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_26 XP0_1 XP0_2 GTP WL0_26 WL1_26 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_27 XP0_1 XP0_2 GTP WL0_27 WL1_27 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_28 XP0_1 XP1_2 XP0_2 GTP WL0_28 WL1_28 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_29 XP0_1 XP1_2 GTP WL0_29 WL1_29 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_3 XP0_1 XP0_5 GTP WL0_3 WL1_3 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_30 XP0_1 XP1_2 GTP WL0_30 WL1_30 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_31 XP0_1 XP1_2 GTP WL0_31 WL1_31 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_32 XP1_1 XP0_1 XP0_5 XP1_2 GTP WL0_32 WL1_32 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_64
XI0_33 XP1_1 XP0_5 GTP WL0_33 WL1_33 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_34 XP1_1 XP0_5 GTP WL0_34 WL1_34 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_35 XP1_1 XP0_5 GTP WL0_35 WL1_35 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_36 XP1_1 XP1_5 XP0_5 GTP WL0_36 WL1_36 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_37 XP1_1 XP1_5 GTP WL0_37 WL1_37 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_38 XP1_1 XP1_5 GTP WL0_38 WL1_38 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_39 XP1_1 XP1_5 GTP WL0_39 WL1_39 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_4 XP0_1 XP1_5 XP0_5 GTP WL0_4 WL1_4 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_40 XP1_1 XP0_4 XP1_5 GTP WL0_40 WL1_40 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_41 XP1_1 XP0_4 GTP WL0_41 WL1_41 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_42 XP1_1 XP0_4 GTP WL0_42 WL1_42 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_43 XP1_1 XP0_4 GTP WL0_43 WL1_43 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_44 XP1_1 XP1_4 XP0_4 GTP WL0_44 WL1_44 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_45 XP1_1 XP1_4 GTP WL0_45 WL1_45 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_46 XP1_1 XP1_4 GTP WL0_46 WL1_46 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_47 XP1_1 XP1_4 GTP WL0_47 WL1_47 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_48 XP1_1 XP0_3 XP1_4 GTP WL0_48 WL1_48 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_49 XP1_1 XP0_3 GTP WL0_49 WL1_49 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_5 XP0_1 XP1_5 GTP WL0_5 WL1_5 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_50 XP1_1 XP0_3 GTP WL0_50 WL1_50 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_51 XP1_1 XP0_3 GTP WL0_51 WL1_51 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_52 XP1_1 XP1_3 XP0_3 GTP WL0_52 WL1_52 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_53 XP1_1 XP1_3 GTP WL0_53 WL1_53 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_54 XP1_1 XP1_3 GTP WL0_54 WL1_54 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_55 XP1_1 XP1_3 GTP WL0_55 WL1_55 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_56 XP1_1 XP0_2 XP1_3 GTP WL0_56 WL1_56 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_57 XP1_1 XP0_2 GTP WL0_57 WL1_57 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_58 XP1_1 XP0_2 GTP WL0_58 WL1_58 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_59 XP1_1 XP0_2 GTP WL0_59 WL1_59 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_6 XP0_1 XP1_5 GTP WL0_6 WL1_6 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_60 XP1_1 XP1_2 XP0_2 GTP WL0_60 WL1_60 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_61 XP1_1 XP1_2 GTP WL0_61 WL1_61 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_62 XP1_1 XP1_2 GTP WL0_62 WL1_62 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_63 XP1_1 XP1_2 GTP WL0_63 WL1_63 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_64 XP0_0 XP1_1 XP0_5 XP1_2 GTP WL0_64 WL1_64 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_64
XI0_65 XP0_0 XP0_5 GTP WL0_65 WL1_65 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_66 XP0_0 XP0_5 GTP WL0_66 WL1_66 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_67 XP0_0 XP0_5 GTP WL0_67 WL1_67 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_68 XP0_0 XP1_5 XP0_5 GTP WL0_68 WL1_68 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_69 XP0_0 XP1_5 GTP WL0_69 WL1_69 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_7 XP0_1 XP1_5 GTP WL0_7 WL1_7 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_70 XP0_0 XP1_5 GTP WL0_70 WL1_70 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_71 XP0_0 XP1_5 GTP WL0_71 WL1_71 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_72 XP0_0 XP0_4 XP1_5 GTP WL0_72 WL1_72 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_73 XP0_0 XP0_4 GTP WL0_73 WL1_73 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_74 XP0_0 XP0_4 GTP WL0_74 WL1_74 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_75 XP0_0 XP0_4 GTP WL0_75 WL1_75 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_76 XP0_0 XP1_4 XP0_4 GTP WL0_76 WL1_76 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_77 XP0_0 XP1_4 GTP WL0_77 WL1_77 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_78 XP0_0 XP1_4 GTP WL0_78 WL1_78 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_79 XP0_0 XP1_4 GTP WL0_79 WL1_79 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_8 XP0_1 XP0_4 XP1_5 GTP WL0_8 WL1_8 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_80 XP0_0 XP0_3 XP1_4 GTP WL0_80 WL1_80 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_81 XP0_0 XP0_3 GTP WL0_81 WL1_81 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_82 XP0_0 XP0_3 GTP WL0_82 WL1_82 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_83 XP0_0 XP0_3 GTP WL0_83 WL1_83 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_84 XP0_0 XP1_3 XP0_3 GTP WL0_84 WL1_84 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_85 XP0_0 XP1_3 GTP WL0_85 WL1_85 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_86 XP0_0 XP1_3 GTP WL0_86 WL1_86 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_87 XP0_0 XP1_3 GTP WL0_87 WL1_87 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_88 XP0_0 XP0_2 XP1_3 GTP WL0_88 WL1_88 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_89 XP0_0 XP0_2 GTP WL0_89 WL1_89 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_9 XP0_1 XP0_4 GTP WL0_9 WL1_9 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_90 XP0_0 XP0_2 GTP WL0_90 WL1_90 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_91 XP0_0 XP0_2 GTP WL0_91 WL1_91 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_92 XP0_0 XP1_2 XP0_2 GTP WL0_92 WL1_92 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_8
XI0_93 XP0_0 XP1_2 GTP WL0_93 WL1_93 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_94 XP0_0 XP1_2 GTP WL0_94 WL1_94 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_95 XP0_0 XP1_2 GTP WL0_95 WL1_95 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
XI0_96 XP1_0 XP0_0 XP0_5 XP1_2 GTP WL0_96 WL1_96 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA1SHD_2048x32M8ROW_64
XI0_97 XP1_0 XP0_5 GTP WL0_97 WL1_97 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER1
XI0_98 XP1_0 XP0_5 GTP WL0_98 WL1_98 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER2
XI0_99 XP1_0 XP0_5 GTP WL0_99 WL1_99 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SHD_2048x32M8ROW_FILLER3
.ENDS RA1SHD_2048x32M8WORD_ROWS
****
.SUBCKT RA1SHD_2048x32M8HCKA A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8HCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK CK-GTPFEED VSS N L=0.18U W=11.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 AGTP GTPN VDD VDD P L=0.18U W=40U
m5 AGTP GTPN VSS VSS N L=0.18U W=22U
m6 CK-GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 CK-GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 CK-GTPFEED CLK CK-SRCFEED VSS N L=0.18U W=11.84U
m9 CK-GTPFEED GTPN VDD VSS N L=0.18U W=3.76U
.ENDS RA1SHD_2048x32M8HCKA
****
.SUBCKT RA1SHD_2048x32M8CK A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8CK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK GTPFEED VSS N L=0.18U W=11.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 GTP GTPN VDD VDD P L=0.18U W=40U
m5 GTP GTPN VSS VSS N L=0.18U W=22U
m6 GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 GTPFEED CLK SRCFEED VSS N L=0.18U W=11.84U
m9 GTPFEED GTPN VDD VSS N L=0.18U W=3.76U
.ENDS RA1SHD_2048x32M8CK
****
.SUBCKT RA1SHD_2048x32M8CLK_DRVS A0 A0_ AGTP CLK GSRCN GTPN GTP_0 GTP_1 GTP_2
+  GTP_3 RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8CLK_DRVS: 45 flat devices **
XI0_0 A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SHD_2048x32M8HCKA
XI1_0 A0 A0_ CLK GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8CK
XI2_0 A0 A0_ CLK GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8CK
XI3_0 A0 A0_ CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8CK
XI4_0 A0 A0_ CLK GSRCN GTP_3 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8CK
.ENDS RA1SHD_2048x32M8CLK_DRVS
****
.SUBCKT RA1SHD_2048x32M8WING_16_RIGHT A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL_127 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 BWEN_0 BWEN_1 D_0 D_1 D_2 D_3 D_4 D_5 D_6
+  D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 GTP_0 GTP_1 GTP_2 OE_ Q_0 Q_1 Q_2
+  Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 STUBDR_0 STUBDR_1
+  STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8WING_16_RIGHT: 202572 flat devices **
XI0_0 A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BWEN_0 D_0 GTP_0 GTP_1 GTP_2 OE_ Q_0 STUBDR_0_66
+  STUBDR_1 STUBDR__0_64 STUBDR__1 STUBDW_0_68 STUBDW_1 STUBDW__0_70 STUBDW__1
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD RA1SHD_2048x32M8MCOL_EVEN_LE8
XI10_0 A0 A0_ BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL__64 BL__65
+  BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BWEN_1 D_8 GTP_0 GTP_1 GTP_2 OE_
+  Q_8 STUBDR_0_2 STUBDR_1_10 STUBDR__0_0 STUBDR__1_8 STUBDW_0_4 STUBDW_1_12
+  STUBDW__0_6 STUBDW__1_14 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_LE8
XI11_0 A0 A0_ BL_79 BL_78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL__79 BL__78
+  BL__77 BL__76 BL__75 BL__74 BL__73 BL__72 BWEN_1 D_9 GTP_0 GTP_1 GTP_2 OE_
+  Q_9 STUBDR_0_2 STUBDR_1_18 STUBDR__0_0 STUBDR__1_16 STUBDW_0_4 STUBDW_1_20
+  STUBDW__0_6 STUBDW__1_22 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI12_0 A0 A0_ BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL__80 BL__81
+  BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BWEN_1 D_10 GTP_0 GTP_1 GTP_2 OE_
+  Q_10 STUBDR_0_26 STUBDR_1_18 STUBDR__0_24 STUBDR__1_16 STUBDW_0_28
+  STUBDW_1_20 STUBDW__0_30 STUBDW__1_22 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI13_0 A0 A0_ BL_95 BL_94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL__95 BL__94
+  BL__93 BL__92 BL__91 BL__90 BL__89 BL__88 BWEN_1 D_11 GTP_0 GTP_1 GTP_2 OE_
+  Q_11 STUBDR_0_26 STUBDR_1_34 STUBDR__0_24 STUBDR__1_32 STUBDW_0_28
+  STUBDW_1_36 STUBDW__0_30 STUBDW__1_38 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI14_0 A0 A0_ STUBDR_1_34 STUBDR__1_32 STUBDW_1_36 STUBDW__1_38 GTP_0 GTP_1
+  GTP_2 OE_ BWEN_1 VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8COL_STRAP
XI15_0 A0 A0_ BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BWEN_1 D_12 GTP_0
+  GTP_1 GTP_2 OE_ Q_12 STUBDR_0_42 STUBDR_1_34 STUBDR__0_40 STUBDR__1_32
+  STUBDW_0_44 STUBDW_1_36 STUBDW__0_46 STUBDW__1_38 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_EVEN_M8
XI16_0 A0 A0_ BL_111 BL_110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL__111
+  BL__110 BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BWEN_1 D_13 GTP_0
+  GTP_1 GTP_2 OE_ Q_13 STUBDR_0_42 STUBDR_1_50 STUBDR__0_40 STUBDR__1_48
+  STUBDW_0_44 STUBDW_1_52 STUBDW__0_46 STUBDW__1_54 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_ODD_M8
XI17_0 A0 A0_ BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL__112
+  BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BL__119 BWEN_1 D_14 GTP_0
+  GTP_1 GTP_2 OE_ Q_14 STUBDR_0_58 STUBDR_1_50 STUBDR__0_56 STUBDR__1_48
+  STUBDW_0_60 STUBDW_1_52 STUBDW__0_62 STUBDW__1_54 WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_EVEN_M8
XI18_0 A0 A0_ BL_127 BL_126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL__127
+  BL__126 BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BWEN_1 D_15 GTP_0
+  GTP_1 GTP_2 OE_ Q_15 STUBDR_0_58 STUBDR_0 STUBDR__0_56 STUBDR__0
+  STUBDW_0_60 STUBDW_0 STUBDW__0_62 STUBDW__0 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8MCOL_ODD_RO8
XI1_0 A0 A0_ BL_15 BL_14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL__15 BL__14
+  BL__13 BL__12 BL__11 BL__10 BL__9 BL__8 BWEN_0 D_1 GTP_0 GTP_1 GTP_2 OE_
+  Q_1 STUBDR_0_66 STUBDR_1_74 STUBDR__0_64 STUBDR__1_72 STUBDW_0_68
+  STUBDW_1_76 STUBDW__0_70 STUBDW__1_78 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI2_0 A0 A0_ BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL__16 BL__17
+  BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BWEN_0 D_2 GTP_0 GTP_1 GTP_2 OE_
+  Q_2 STUBDR_0_82 STUBDR_1_74 STUBDR__0_80 STUBDR__1_72 STUBDW_0_84
+  STUBDW_1_76 STUBDW__0_86 STUBDW__1_78 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI3_0 A0 A0_ BL_31 BL_30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL__31 BL__30
+  BL__29 BL__28 BL__27 BL__26 BL__25 BL__24 BWEN_0 D_3 GTP_0 GTP_1 GTP_2 OE_
+  Q_3 STUBDR_0_82 STUBDR_1_90 STUBDR__0_80 STUBDR__1_88 STUBDW_0_84
+  STUBDW_1_92 STUBDW__0_86 STUBDW__1_94 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI4_0 A0 A0_ STUBDR_1_90 STUBDR__1_88 STUBDW_1_92 STUBDW__1_94 GTP_0 GTP_1
+  GTP_2 OE_ BWEN_0 VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69
+  WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81
+  WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93
+  WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104
+  WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114
+  WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124
+  WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134
+  WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144
+  WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154
+  WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164
+  WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174
+  WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184
+  WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194
+  WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204
+  WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214
+  WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224
+  WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234
+  WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244
+  WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254
+  WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8COL_STRAP
XI5_0 A0 A0_ BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL__32 BL__33
+  BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BWEN_0 D_4 GTP_0 GTP_1 GTP_2 OE_
+  Q_4 STUBDR_0_98 STUBDR_1_90 STUBDR__0_96 STUBDR__1_88 STUBDW_0_100
+  STUBDW_1_92 STUBDW__0_102 STUBDW__1_94 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI6_0 A0 A0_ BL_47 BL_46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL__47 BL__46
+  BL__45 BL__44 BL__43 BL__42 BL__41 BL__40 BWEN_0 D_5 GTP_0 GTP_1 GTP_2 OE_
+  Q_5 STUBDR_0_98 STUBDR_1_106 STUBDR__0_96 STUBDR__1_104 STUBDW_0_100
+  STUBDW_1_108 STUBDW__0_102 STUBDW__1_110 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_M8
XI7_0 A0 A0_ BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BWEN_0 D_6 GTP_0 GTP_1 GTP_2 OE_
+  Q_6 STUBDR_0_114 STUBDR_1_106 STUBDR__0_112 STUBDR__1_104 STUBDW_0_116
+  STUBDW_1_108 STUBDW__0_118 STUBDW__1_110 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_EVEN_M8
XI8_0 A0 A0_ BL_63 BL_62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL__63 BL__62
+  BL__61 BL__60 BL__59 BL__58 BL__57 BL__56 BWEN_0 D_7 GTP_0 GTP_1 GTP_2 OE_
+  Q_7 STUBDR_0_114 STUBDR_1_10 STUBDR__0_112 STUBDR__1_8 STUBDW_0_116
+  STUBDW_1_12 STUBDW__0_118 STUBDW__1_14 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67
+  WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79
+  WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91
+  WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8MCOL_ODD_RO8
XI9_0 A0 A0_ STUBDR_1_10 STUBDR__1_8 STUBDW_1_12 STUBDW__1_14 GTP_0 GTP_1
+  GTP_2 OE_ VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SHD_2048x32M8COL_STRAPX
.ENDS RA1SHD_2048x32M8WING_16_RIGHT
****
.SUBCKT RA1SHD_2048x32M8FLCIO A0 A0_ CLK GSRCN GTP GTPN MBL MBL_ RST YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8FLCIO: 11 flat devices **
d1 VSS GTP DN 0.2401P 2.32U
d10 VSS A0_ DN 0.2401P 2.32U
d11 VSS A0 DN 0.2401P 2.32U
d2 VSS YP0_0 DN 0.2401P 2.32U
d3 VSS YP1_0 DN 0.2401P 2.32U
d4 VSS YP0_1 DN 0.2401P 2.32U
d5 VSS YP0_2 DN 0.2401P 2.32U
d6 VSS YP0_3 DN 0.2401P 2.32U
d7 VSS YP1_1 DN 0.2401P 2.32U
d8 VSS YP1_2 DN 0.2401P 2.32U
d9 VSS YP1_3 DN 0.2401P 2.32U
.ENDS RA1SHD_2048x32M8FLCIO
****
.SUBCKT RA1SHD_2048x32M8FCCDR A0 A0_ GTP VD YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8FCCDR: 1 flat devices **
m1 VDD VSS VD VDD P L=0.18U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P PS=1.18U
.ENDS RA1SHD_2048x32M8FCCDR
****
.SUBCKT RA1SHD_2048x32M8RIGHT_CAP A0 A0_ GTP_0 GTP_1 GTP_2 OE_ WE WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SHD_2048x32M8RIGHT_CAP: 2069 flat devices **
XI0_0 GTP_0 OE_ WE VSS VDD RA1SHD_2048x32M8FCIO8
XI0_1 GTP_1 VSS VDD RA1SHD_2048x32M8FCSA8
XI0_10 BL BL WL_6 WL_6 VSS VDD RA1SHD_2048x32M8CCG
XI0_100 BL BL WL_96 WL_96 VSS VDD RA1SHD_2048x32M8CCG
XI0_101 BL BL WL_97 WL_97 VSS VDD RA1SHD_2048x32M8CCG
XI0_102 BL BL WL_98 WL_98 VSS VDD RA1SHD_2048x32M8CCG
XI0_103 BL BL WL_99 WL_99 VSS VDD RA1SHD_2048x32M8CCG
XI0_104 BL BL WL_100 WL_100 VSS VDD RA1SHD_2048x32M8CCG
XI0_105 BL BL WL_101 WL_101 VSS VDD RA1SHD_2048x32M8CCG
XI0_106 BL BL WL_102 WL_102 VSS VDD RA1SHD_2048x32M8CCG
XI0_107 BL BL WL_103 WL_103 VSS VDD RA1SHD_2048x32M8CCG
XI0_108 BL BL WL_104 WL_104 VSS VDD RA1SHD_2048x32M8CCG
XI0_109 BL BL WL_105 WL_105 VSS VDD RA1SHD_2048x32M8CCG
XI0_11 BL BL WL_7 WL_7 VSS VDD RA1SHD_2048x32M8CCG
XI0_110 BL BL WL_106 WL_106 VSS VDD RA1SHD_2048x32M8CCG
XI0_111 BL BL WL_107 WL_107 VSS VDD RA1SHD_2048x32M8CCG
XI0_112 BL BL WL_108 WL_108 VSS VDD RA1SHD_2048x32M8CCG
XI0_113 BL BL WL_109 WL_109 VSS VDD RA1SHD_2048x32M8CCG
XI0_114 BL BL WL_110 WL_110 VSS VDD RA1SHD_2048x32M8CCG
XI0_115 BL BL WL_111 WL_111 VSS VDD RA1SHD_2048x32M8CCG
XI0_116 BL BL WL_112 WL_112 VSS VDD RA1SHD_2048x32M8CCG
XI0_117 BL BL WL_113 WL_113 VSS VDD RA1SHD_2048x32M8CCG
XI0_118 BL BL WL_114 WL_114 VSS VDD RA1SHD_2048x32M8CCG
XI0_119 BL BL WL_115 WL_115 VSS VDD RA1SHD_2048x32M8CCG
XI0_12 BL BL WL_8 WL_8 VSS VDD RA1SHD_2048x32M8CCG
XI0_120 BL BL WL_116 WL_116 VSS VDD RA1SHD_2048x32M8CCG
XI0_121 BL BL WL_117 WL_117 VSS VDD RA1SHD_2048x32M8CCG
XI0_122 BL BL WL_118 WL_118 VSS VDD RA1SHD_2048x32M8CCG
XI0_123 BL BL WL_119 WL_119 VSS VDD RA1SHD_2048x32M8CCG
XI0_124 BL BL WL_120 WL_120 VSS VDD RA1SHD_2048x32M8CCG
XI0_125 BL BL WL_121 WL_121 VSS VDD RA1SHD_2048x32M8CCG
XI0_126 BL BL WL_122 WL_122 VSS VDD RA1SHD_2048x32M8CCG
XI0_127 BL BL WL_123 WL_123 VSS VDD RA1SHD_2048x32M8CCG
XI0_128 BL BL WL_124 WL_124 VSS VDD RA1SHD_2048x32M8CCG
XI0_129 BL BL WL_125 WL_125 VSS VDD RA1SHD_2048x32M8CCG
XI0_13 BL BL WL_9 WL_9 VSS VDD RA1SHD_2048x32M8CCG
XI0_130 BL BL WL_126 WL_126 VSS VDD RA1SHD_2048x32M8CCG
XI0_131 BL BL WL_127 WL_127 VSS VDD RA1SHD_2048x32M8CCG
XI0_132 BL BL WL_128 WL_128 VSS VDD RA1SHD_2048x32M8CCG
XI0_133 BL BL WL_129 WL_129 VSS VDD RA1SHD_2048x32M8CCG
XI0_134 BL BL WL_130 WL_130 VSS VDD RA1SHD_2048x32M8CCG
XI0_135 BL BL WL_131 WL_131 VSS VDD RA1SHD_2048x32M8CCG
XI0_136 BL BL WL_132 WL_132 VSS VDD RA1SHD_2048x32M8CCG
XI0_137 BL BL WL_133 WL_133 VSS VDD RA1SHD_2048x32M8CCG
XI0_138 BL BL WL_134 WL_134 VSS VDD RA1SHD_2048x32M8CCG
XI0_139 BL BL WL_135 WL_135 VSS VDD RA1SHD_2048x32M8CCG
XI0_14 BL BL WL_10 WL_10 VSS VDD RA1SHD_2048x32M8CCG
XI0_140 BL BL WL_136 WL_136 VSS VDD RA1SHD_2048x32M8CCG
XI0_141 BL BL WL_137 WL_137 VSS VDD RA1SHD_2048x32M8CCG
XI0_142 BL BL WL_138 WL_138 VSS VDD RA1SHD_2048x32M8CCG
XI0_143 BL BL WL_139 WL_139 VSS VDD RA1SHD_2048x32M8CCG
XI0_144 BL BL WL_140 WL_140 VSS VDD RA1SHD_2048x32M8CCG
XI0_145 BL BL WL_141 WL_141 VSS VDD RA1SHD_2048x32M8CCG
XI0_146 BL BL WL_142 WL_142 VSS VDD RA1SHD_2048x32M8CCG
XI0_147 BL BL WL_143 WL_143 VSS VDD RA1SHD_2048x32M8CCG
XI0_148 BL BL WL_144 WL_144 VSS VDD RA1SHD_2048x32M8CCG
XI0_149 BL BL WL_145 WL_145 VSS VDD RA1SHD_2048x32M8CCG
XI0_15 BL BL WL_11 WL_11 VSS VDD RA1SHD_2048x32M8CCG
XI0_150 BL BL WL_146 WL_146 VSS VDD RA1SHD_2048x32M8CCG
XI0_151 BL BL WL_147 WL_147 VSS VDD RA1SHD_2048x32M8CCG
XI0_152 BL BL WL_148 WL_148 VSS VDD RA1SHD_2048x32M8CCG
XI0_153 BL BL WL_149 WL_149 VSS VDD RA1SHD_2048x32M8CCG
XI0_154 BL BL WL_150 WL_150 VSS VDD RA1SHD_2048x32M8CCG
XI0_155 BL BL WL_151 WL_151 VSS VDD RA1SHD_2048x32M8CCG
XI0_156 BL BL WL_152 WL_152 VSS VDD RA1SHD_2048x32M8CCG
XI0_157 BL BL WL_153 WL_153 VSS VDD RA1SHD_2048x32M8CCG
XI0_158 BL BL WL_154 WL_154 VSS VDD RA1SHD_2048x32M8CCG
XI0_159 BL BL WL_155 WL_155 VSS VDD RA1SHD_2048x32M8CCG
XI0_16 BL BL WL_12 WL_12 VSS VDD RA1SHD_2048x32M8CCG
XI0_160 BL BL WL_156 WL_156 VSS VDD RA1SHD_2048x32M8CCG
XI0_161 BL BL WL_157 WL_157 VSS VDD RA1SHD_2048x32M8CCG
XI0_162 BL BL WL_158 WL_158 VSS VDD RA1SHD_2048x32M8CCG
XI0_163 BL BL WL_159 WL_159 VSS VDD RA1SHD_2048x32M8CCG
XI0_164 BL BL WL_160 WL_160 VSS VDD RA1SHD_2048x32M8CCG
XI0_165 BL BL WL_161 WL_161 VSS VDD RA1SHD_2048x32M8CCG
XI0_166 BL BL WL_162 WL_162 VSS VDD RA1SHD_2048x32M8CCG
XI0_167 BL BL WL_163 WL_163 VSS VDD RA1SHD_2048x32M8CCG
XI0_168 BL BL WL_164 WL_164 VSS VDD RA1SHD_2048x32M8CCG
XI0_169 BL BL WL_165 WL_165 VSS VDD RA1SHD_2048x32M8CCG
XI0_17 BL BL WL_13 WL_13 VSS VDD RA1SHD_2048x32M8CCG
XI0_170 BL BL WL_166 WL_166 VSS VDD RA1SHD_2048x32M8CCG
XI0_171 BL BL WL_167 WL_167 VSS VDD RA1SHD_2048x32M8CCG
XI0_172 BL BL WL_168 WL_168 VSS VDD RA1SHD_2048x32M8CCG
XI0_173 BL BL WL_169 WL_169 VSS VDD RA1SHD_2048x32M8CCG
XI0_174 BL BL WL_170 WL_170 VSS VDD RA1SHD_2048x32M8CCG
XI0_175 BL BL WL_171 WL_171 VSS VDD RA1SHD_2048x32M8CCG
XI0_176 BL BL WL_172 WL_172 VSS VDD RA1SHD_2048x32M8CCG
XI0_177 BL BL WL_173 WL_173 VSS VDD RA1SHD_2048x32M8CCG
XI0_178 BL BL WL_174 WL_174 VSS VDD RA1SHD_2048x32M8CCG
XI0_179 BL BL WL_175 WL_175 VSS VDD RA1SHD_2048x32M8CCG
XI0_18 BL BL WL_14 WL_14 VSS VDD RA1SHD_2048x32M8CCG
XI0_180 BL BL WL_176 WL_176 VSS VDD RA1SHD_2048x32M8CCG
XI0_181 BL BL WL_177 WL_177 VSS VDD RA1SHD_2048x32M8CCG
XI0_182 BL BL WL_178 WL_178 VSS VDD RA1SHD_2048x32M8CCG
XI0_183 BL BL WL_179 WL_179 VSS VDD RA1SHD_2048x32M8CCG
XI0_184 BL BL WL_180 WL_180 VSS VDD RA1SHD_2048x32M8CCG
XI0_185 BL BL WL_181 WL_181 VSS VDD RA1SHD_2048x32M8CCG
XI0_186 BL BL WL_182 WL_182 VSS VDD RA1SHD_2048x32M8CCG
XI0_187 BL BL WL_183 WL_183 VSS VDD RA1SHD_2048x32M8CCG
XI0_188 BL BL WL_184 WL_184 VSS VDD RA1SHD_2048x32M8CCG
XI0_189 BL BL WL_185 WL_185 VSS VDD RA1SHD_2048x32M8CCG
XI0_19 BL BL WL_15 WL_15 VSS VDD RA1SHD_2048x32M8CCG
XI0_190 BL BL WL_186 WL_186 VSS VDD RA1SHD_2048x32M8CCG
XI0_191 BL BL WL_187 WL_187 VSS VDD RA1SHD_2048x32M8CCG
XI0_192 BL BL WL_188 WL_188 VSS VDD RA1SHD_2048x32M8CCG
XI0_193 BL BL WL_189 WL_189 VSS VDD RA1SHD_2048x32M8CCG
XI0_194 BL BL WL_190 WL_190 VSS VDD RA1SHD_2048x32M8CCG
XI0_195 BL BL WL_191 WL_191 VSS VDD RA1SHD_2048x32M8CCG
XI0_196 BL BL WL_192 WL_192 VSS VDD RA1SHD_2048x32M8CCG
XI0_197 BL BL WL_193 WL_193 VSS VDD RA1SHD_2048x32M8CCG
XI0_198 BL BL WL_194 WL_194 VSS VDD RA1SHD_2048x32M8CCG
XI0_199 BL BL WL_195 WL_195 VSS VDD RA1SHD_2048x32M8CCG
XI0_2 A0 A0_ GTP_2 BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SHD_2048x32M8FCCDR
XI0_20 BL BL WL_16 WL_16 VSS VDD RA1SHD_2048x32M8CCG
XI0_200 BL BL WL_196 WL_196 VSS VDD RA1SHD_2048x32M8CCG
XI0_201 BL BL WL_197 WL_197 VSS VDD RA1SHD_2048x32M8CCG
XI0_202 BL BL WL_198 WL_198 VSS VDD RA1SHD_2048x32M8CCG
XI0_203 BL BL WL_199 WL_199 VSS VDD RA1SHD_2048x32M8CCG
XI0_204 BL BL WL_200 WL_200 VSS VDD RA1SHD_2048x32M8CCG
XI0_205 BL BL WL_201 WL_201 VSS VDD RA1SHD_2048x32M8CCG
XI0_206 BL BL WL_202 WL_202 VSS VDD RA1SHD_2048x32M8CCG
XI0_207 BL BL WL_203 WL_203 VSS VDD RA1SHD_2048x32M8CCG
XI0_208 BL BL WL_204 WL_204 VSS VDD RA1SHD_2048x32M8CCG
XI0_209 BL BL WL_205 WL_205 VSS VDD RA1SHD_2048x32M8CCG
XI0_21 BL BL WL_17 WL_17 VSS VDD RA1SHD_2048x32M8CCG
XI0_210 BL BL WL_206 WL_206 VSS VDD RA1SHD_2048x32M8CCG
XI0_211 BL BL WL_207 WL_207 VSS VDD RA1SHD_2048x32M8CCG
XI0_212 BL BL WL_208 WL_208 VSS VDD RA1SHD_2048x32M8CCG
XI0_213 BL BL WL_209 WL_209 VSS VDD RA1SHD_2048x32M8CCG
XI0_214 BL BL WL_210 WL_210 VSS VDD RA1SHD_2048x32M8CCG
XI0_215 BL BL WL_211 WL_211 VSS VDD RA1SHD_2048x32M8CCG
XI0_216 BL BL WL_212 WL_212 VSS VDD RA1SHD_2048x32M8CCG
XI0_217 BL BL WL_213 WL_213 VSS VDD RA1SHD_2048x32M8CCG
XI0_218 BL BL WL_214 WL_214 VSS VDD RA1SHD_2048x32M8CCG
XI0_219 BL BL WL_215 WL_215 VSS VDD RA1SHD_2048x32M8CCG
XI0_22 BL BL WL_18 WL_18 VSS VDD RA1SHD_2048x32M8CCG
XI0_220 BL BL WL_216 WL_216 VSS VDD RA1SHD_2048x32M8CCG
XI0_221 BL BL WL_217 WL_217 VSS VDD RA1SHD_2048x32M8CCG
XI0_222 BL BL WL_218 WL_218 VSS VDD RA1SHD_2048x32M8CCG
XI0_223 BL BL WL_219 WL_219 VSS VDD RA1SHD_2048x32M8CCG
XI0_224 BL BL WL_220 WL_220 VSS VDD RA1SHD_2048x32M8CCG
XI0_225 BL BL WL_221 WL_221 VSS VDD RA1SHD_2048x32M8CCG
XI0_226 BL BL WL_222 WL_222 VSS VDD RA1SHD_2048x32M8CCG
XI0_227 BL BL WL_223 WL_223 VSS VDD RA1SHD_2048x32M8CCG
XI0_228 BL BL WL_224 WL_224 VSS VDD RA1SHD_2048x32M8CCG
XI0_229 BL BL WL_225 WL_225 VSS VDD RA1SHD_2048x32M8CCG
XI0_23 BL BL WL_19 WL_19 VSS VDD RA1SHD_2048x32M8CCG
XI0_230 BL BL WL_226 WL_226 VSS VDD RA1SHD_2048x32M8CCG
XI0_231 BL BL WL_227 WL_227 VSS VDD RA1SHD_2048x32M8CCG
XI0_232 BL BL WL_228 WL_228 VSS VDD RA1SHD_2048x32M8CCG
XI0_233 BL BL WL_229 WL_229 VSS VDD RA1SHD_2048x32M8CCG
XI0_234 BL BL WL_230 WL_230 VSS VDD RA1SHD_2048x32M8CCG
XI0_235 BL BL WL_231 WL_231 VSS VDD RA1SHD_2048x32M8CCG
XI0_236 BL BL WL_232 WL_232 VSS VDD RA1SHD_2048x32M8CCG
XI0_237 BL BL WL_233 WL_233 VSS VDD RA1SHD_2048x32M8CCG
XI0_238 BL BL WL_234 WL_234 VSS VDD RA1SHD_2048x32M8CCG
XI0_239 BL BL WL_235 WL_235 VSS VDD RA1SHD_2048x32M8CCG
XI0_24 BL BL WL_20 WL_20 VSS VDD RA1SHD_2048x32M8CCG
XI0_240 BL BL WL_236 WL_236 VSS VDD RA1SHD_2048x32M8CCG
XI0_241 BL BL WL_237 WL_237 VSS VDD RA1SHD_2048x32M8CCG
XI0_242 BL BL WL_238 WL_238 VSS VDD RA1SHD_2048x32M8CCG
XI0_243 BL BL WL_239 WL_239 VSS VDD RA1SHD_2048x32M8CCG
XI0_244 BL BL WL_240 WL_240 VSS VDD RA1SHD_2048x32M8CCG
XI0_245 BL BL WL_241 WL_241 VSS VDD RA1SHD_2048x32M8CCG
XI0_246 BL BL WL_242 WL_242 VSS VDD RA1SHD_2048x32M8CCG
XI0_247 BL BL WL_243 WL_243 VSS VDD RA1SHD_2048x32M8CCG
XI0_248 BL BL WL_244 WL_244 VSS VDD RA1SHD_2048x32M8CCG
XI0_249 BL BL WL_245 WL_245 VSS VDD RA1SHD_2048x32M8CCG
XI0_25 BL BL WL_21 WL_21 VSS VDD RA1SHD_2048x32M8CCG
XI0_250 BL BL WL_246 WL_246 VSS VDD RA1SHD_2048x32M8CCG
XI0_251 BL BL WL_247 WL_247 VSS VDD RA1SHD_2048x32M8CCG
XI0_252 BL BL WL_248 WL_248 VSS VDD RA1SHD_2048x32M8CCG
XI0_253 BL BL WL_249 WL_249 VSS VDD RA1SHD_2048x32M8CCG
XI0_254 BL BL WL_250 WL_250 VSS VDD RA1SHD_2048x32M8CCG
XI0_255 BL BL WL_251 WL_251 VSS VDD RA1SHD_2048x32M8CCG
XI0_256 BL BL WL_252 WL_252 VSS VDD RA1SHD_2048x32M8CCG
XI0_257 BL BL WL_253 WL_253 VSS VDD RA1SHD_2048x32M8CCG
XI0_258 BL BL WL_254 WL_254 VSS VDD RA1SHD_2048x32M8CCG
XI0_259 BL BL WL_255 WL_255 VSS VDD RA1SHD_2048x32M8CCG
XI0_26 BL BL WL_22 WL_22 VSS VDD RA1SHD_2048x32M8CCG
XI0_260 BL BL VSS VSS VSS VDD RA1SHD_2048x32M8CCG
XI0_261 BL BL VSS VSS VSS VDD RA1SHD_2048x32M8CCG
XI0_27 BL BL WL_23 WL_23 VSS VDD RA1SHD_2048x32M8CCG
XI0_28 BL BL WL_24 WL_24 VSS VDD RA1SHD_2048x32M8CCG
XI0_29 BL BL WL_25 WL_25 VSS VDD RA1SHD_2048x32M8CCG
XI0_30 BL BL WL_26 WL_26 VSS VDD RA1SHD_2048x32M8CCG
XI0_31 BL BL WL_27 WL_27 VSS VDD RA1SHD_2048x32M8CCG
XI0_32 BL BL WL_28 WL_28 VSS VDD RA1SHD_2048x32M8CCG
XI0_33 BL BL WL_29 WL_29 VSS VDD RA1SHD_2048x32M8CCG
XI0_34 BL BL WL_30 WL_30 VSS VDD RA1SHD_2048x32M8CCG
XI0_35 BL BL WL_31 WL_31 VSS VDD RA1SHD_2048x32M8CCG
XI0_36 BL BL WL_32 WL_32 VSS VDD RA1SHD_2048x32M8CCG
XI0_37 BL BL WL_33 WL_33 VSS VDD RA1SHD_2048x32M8CCG
XI0_38 BL BL WL_34 WL_34 VSS VDD RA1SHD_2048x32M8CCG
XI0_39 BL BL WL_35 WL_35 VSS VDD RA1SHD_2048x32M8CCG
XI0_4 BL BL WL_0 WL_0 VSS VDD RA1SHD_2048x32M8CCG
XI0_40 BL BL WL_36 WL_36 VSS VDD RA1SHD_2048x32M8CCG
XI0_41 BL BL WL_37 WL_37 VSS VDD RA1SHD_2048x32M8CCG
XI0_42 BL BL WL_38 WL_38 VSS VDD RA1SHD_2048x32M8CCG
XI0_43 BL BL WL_39 WL_39 VSS VDD RA1SHD_2048x32M8CCG
XI0_44 BL BL WL_40 WL_40 VSS VDD RA1SHD_2048x32M8CCG
XI0_45 BL BL WL_41 WL_41 VSS VDD RA1SHD_2048x32M8CCG
XI0_46 BL BL WL_42 WL_42 VSS VDD RA1SHD_2048x32M8CCG
XI0_47 BL BL WL_43 WL_43 VSS VDD RA1SHD_2048x32M8CCG
XI0_48 BL BL WL_44 WL_44 VSS VDD RA1SHD_2048x32M8CCG
XI0_49 BL BL WL_45 WL_45 VSS VDD RA1SHD_2048x32M8CCG
XI0_5 BL BL WL_1 WL_1 VSS VDD RA1SHD_2048x32M8CCG
XI0_50 BL BL WL_46 WL_46 VSS VDD RA1SHD_2048x32M8CCG
XI0_51 BL BL WL_47 WL_47 VSS VDD RA1SHD_2048x32M8CCG
XI0_52 BL BL WL_48 WL_48 VSS VDD RA1SHD_2048x32M8CCG
XI0_53 BL BL WL_49 WL_49 VSS VDD RA1SHD_2048x32M8CCG
XI0_54 BL BL WL_50 WL_50 VSS VDD RA1SHD_2048x32M8CCG
XI0_55 BL BL WL_51 WL_51 VSS VDD RA1SHD_2048x32M8CCG
XI0_56 BL BL WL_52 WL_52 VSS VDD RA1SHD_2048x32M8CCG
XI0_57 BL BL WL_53 WL_53 VSS VDD RA1SHD_2048x32M8CCG
XI0_58 BL BL WL_54 WL_54 VSS VDD RA1SHD_2048x32M8CCG
XI0_59 BL BL WL_55 WL_55 VSS VDD RA1SHD_2048x32M8CCG
XI0_6 BL BL WL_2 WL_2 VSS VDD RA1SHD_2048x32M8CCG
XI0_60 BL BL WL_56 WL_56 VSS VDD RA1SHD_2048x32M8CCG
XI0_61 BL BL WL_57 WL_57 VSS VDD RA1SHD_2048x32M8CCG
XI0_62 BL BL WL_58 WL_58 VSS VDD RA1SHD_2048x32M8CCG
XI0_63 BL BL WL_59 WL_59 VSS VDD RA1SHD_2048x32M8CCG
XI0_64 BL BL WL_60 WL_60 VSS VDD RA1SHD_2048x32M8CCG
XI0_65 BL BL WL_61 WL_61 VSS VDD RA1SHD_2048x32M8CCG
XI0_66 BL BL WL_62 WL_62 VSS VDD RA1SHD_2048x32M8CCG
XI0_67 BL BL WL_63 WL_63 VSS VDD RA1SHD_2048x32M8CCG
XI0_68 BL BL WL_64 WL_64 VSS VDD RA1SHD_2048x32M8CCG
XI0_69 BL BL WL_65 WL_65 VSS VDD RA1SHD_2048x32M8CCG
XI0_7 BL BL WL_3 WL_3 VSS VDD RA1SHD_2048x32M8CCG
XI0_70 BL BL WL_66 WL_66 VSS VDD RA1SHD_2048x32M8CCG
XI0_71 BL BL WL_67 WL_67 VSS VDD RA1SHD_2048x32M8CCG
XI0_72 BL BL WL_68 WL_68 VSS VDD RA1SHD_2048x32M8CCG
XI0_73 BL BL WL_69 WL_69 VSS VDD RA1SHD_2048x32M8CCG
XI0_74 BL BL WL_70 WL_70 VSS VDD RA1SHD_2048x32M8CCG
XI0_75 BL BL WL_71 WL_71 VSS VDD RA1SHD_2048x32M8CCG
XI0_76 BL BL WL_72 WL_72 VSS VDD RA1SHD_2048x32M8CCG
XI0_77 BL BL WL_73 WL_73 VSS VDD RA1SHD_2048x32M8CCG
XI0_78 BL BL WL_74 WL_74 VSS VDD RA1SHD_2048x32M8CCG
XI0_79 BL BL WL_75 WL_75 VSS VDD RA1SHD_2048x32M8CCG
XI0_8 BL BL WL_4 WL_4 VSS VDD RA1SHD_2048x32M8CCG
XI0_80 BL BL WL_76 WL_76 VSS VDD RA1SHD_2048x32M8CCG
XI0_81 BL BL WL_77 WL_77 VSS VDD RA1SHD_2048x32M8CCG
XI0_82 BL BL WL_78 WL_78 VSS VDD RA1SHD_2048x32M8CCG
XI0_83 BL BL WL_79 WL_79 VSS VDD RA1SHD_2048x32M8CCG
XI0_84 BL BL WL_80 WL_80 VSS VDD RA1SHD_2048x32M8CCG
XI0_85 BL BL WL_81 WL_81 VSS VDD RA1SHD_2048x32M8CCG
XI0_86 BL BL WL_82 WL_82 VSS VDD RA1SHD_2048x32M8CCG
XI0_87 BL BL WL_83 WL_83 VSS VDD RA1SHD_2048x32M8CCG
XI0_88 BL BL WL_84 WL_84 VSS VDD RA1SHD_2048x32M8CCG
XI0_89 BL BL WL_85 WL_85 VSS VDD RA1SHD_2048x32M8CCG
XI0_9 BL BL WL_5 WL_5 VSS VDD RA1SHD_2048x32M8CCG
XI0_90 BL BL WL_86 WL_86 VSS VDD RA1SHD_2048x32M8CCG
XI0_91 BL BL WL_87 WL_87 VSS VDD RA1SHD_2048x32M8CCG
XI0_92 BL BL WL_88 WL_88 VSS VDD RA1SHD_2048x32M8CCG
XI0_93 BL BL WL_89 WL_89 VSS VDD RA1SHD_2048x32M8CCG
XI0_94 BL BL WL_90 WL_90 VSS VDD RA1SHD_2048x32M8CCG
XI0_95 BL BL WL_91 WL_91 VSS VDD RA1SHD_2048x32M8CCG
XI0_96 BL BL WL_92 WL_92 VSS VDD RA1SHD_2048x32M8CCG
XI0_97 BL BL WL_93 WL_93 VSS VDD RA1SHD_2048x32M8CCG
XI0_98 BL BL WL_94 WL_94 VSS VDD RA1SHD_2048x32M8CCG
XI0_99 BL BL WL_95 WL_95 VSS VDD RA1SHD_2048x32M8CCG
XI1_10 WL_6 WL_7 VSS VDD RA1SHD_2048x32M8FCR
XI1_100 WL_96 WL_97 VSS VDD RA1SHD_2048x32M8FCR
XI1_102 WL_98 WL_99 VSS VDD RA1SHD_2048x32M8FCR
XI1_104 WL_100 WL_101 VSS VDD RA1SHD_2048x32M8FCR
XI1_106 WL_102 WL_103 VSS VDD RA1SHD_2048x32M8FCR
XI1_108 WL_104 WL_105 VSS VDD RA1SHD_2048x32M8FCR
XI1_110 WL_106 WL_107 VSS VDD RA1SHD_2048x32M8FCR
XI1_112 WL_108 WL_109 VSS VDD RA1SHD_2048x32M8FCR
XI1_114 WL_110 WL_111 VSS VDD RA1SHD_2048x32M8FCR
XI1_116 WL_112 WL_113 VSS VDD RA1SHD_2048x32M8FCR
XI1_118 WL_114 WL_115 VSS VDD RA1SHD_2048x32M8FCR
XI1_12 WL_8 WL_9 VSS VDD RA1SHD_2048x32M8FCR
XI1_120 WL_116 WL_117 VSS VDD RA1SHD_2048x32M8FCR
XI1_122 WL_118 WL_119 VSS VDD RA1SHD_2048x32M8FCR
XI1_124 WL_120 WL_121 VSS VDD RA1SHD_2048x32M8FCR
XI1_126 WL_122 WL_123 VSS VDD RA1SHD_2048x32M8FCR
XI1_128 WL_124 WL_125 VSS VDD RA1SHD_2048x32M8FCR
XI1_130 WL_126 WL_127 VSS VDD RA1SHD_2048x32M8FCR
XI1_132 WL_128 WL_129 VSS VDD RA1SHD_2048x32M8FCR
XI1_134 WL_130 WL_131 VSS VDD RA1SHD_2048x32M8FCR
XI1_136 WL_132 WL_133 VSS VDD RA1SHD_2048x32M8FCR
XI1_138 WL_134 WL_135 VSS VDD RA1SHD_2048x32M8FCR
XI1_14 WL_10 WL_11 VSS VDD RA1SHD_2048x32M8FCR
XI1_140 WL_136 WL_137 VSS VDD RA1SHD_2048x32M8FCR
XI1_142 WL_138 WL_139 VSS VDD RA1SHD_2048x32M8FCR
XI1_144 WL_140 WL_141 VSS VDD RA1SHD_2048x32M8FCR
XI1_146 WL_142 WL_143 VSS VDD RA1SHD_2048x32M8FCR
XI1_148 WL_144 WL_145 VSS VDD RA1SHD_2048x32M8FCR
XI1_150 WL_146 WL_147 VSS VDD RA1SHD_2048x32M8FCR
XI1_152 WL_148 WL_149 VSS VDD RA1SHD_2048x32M8FCR
XI1_154 WL_150 WL_151 VSS VDD RA1SHD_2048x32M8FCR
XI1_156 WL_152 WL_153 VSS VDD RA1SHD_2048x32M8FCR
XI1_158 WL_154 WL_155 VSS VDD RA1SHD_2048x32M8FCR
XI1_16 WL_12 WL_13 VSS VDD RA1SHD_2048x32M8FCR
XI1_160 WL_156 WL_157 VSS VDD RA1SHD_2048x32M8FCR
XI1_162 WL_158 WL_159 VSS VDD RA1SHD_2048x32M8FCR
XI1_164 WL_160 WL_161 VSS VDD RA1SHD_2048x32M8FCR
XI1_166 WL_162 WL_163 VSS VDD RA1SHD_2048x32M8FCR
XI1_168 WL_164 WL_165 VSS VDD RA1SHD_2048x32M8FCR
XI1_170 WL_166 WL_167 VSS VDD RA1SHD_2048x32M8FCR
XI1_172 WL_168 WL_169 VSS VDD RA1SHD_2048x32M8FCR
XI1_174 WL_170 WL_171 VSS VDD RA1SHD_2048x32M8FCR
XI1_176 WL_172 WL_173 VSS VDD RA1SHD_2048x32M8FCR
XI1_178 WL_174 WL_175 VSS VDD RA1SHD_2048x32M8FCR
XI1_18 WL_14 WL_15 VSS VDD RA1SHD_2048x32M8FCR
XI1_180 WL_176 WL_177 VSS VDD RA1SHD_2048x32M8FCR
XI1_182 WL_178 WL_179 VSS VDD RA1SHD_2048x32M8FCR
XI1_184 WL_180 WL_181 VSS VDD RA1SHD_2048x32M8FCR
XI1_186 WL_182 WL_183 VSS VDD RA1SHD_2048x32M8FCR
XI1_188 WL_184 WL_185 VSS VDD RA1SHD_2048x32M8FCR
XI1_190 WL_186 WL_187 VSS VDD RA1SHD_2048x32M8FCR
XI1_192 WL_188 WL_189 VSS VDD RA1SHD_2048x32M8FCR
XI1_194 WL_190 WL_191 VSS VDD RA1SHD_2048x32M8FCR
XI1_196 WL_192 WL_193 VSS VDD RA1SHD_2048x32M8FCR
XI1_198 WL_194 WL_195 VSS VDD RA1SHD_2048x32M8FCR
XI1_20 WL_16 WL_17 VSS VDD RA1SHD_2048x32M8FCR
XI1_200 WL_196 WL_197 VSS VDD RA1SHD_2048x32M8FCR
XI1_202 WL_198 WL_199 VSS VDD RA1SHD_2048x32M8FCR
XI1_204 WL_200 WL_201 VSS VDD RA1SHD_2048x32M8FCR
XI1_206 WL_202 WL_203 VSS VDD RA1SHD_2048x32M8FCR
XI1_208 WL_204 WL_205 VSS VDD RA1SHD_2048x32M8FCR
XI1_210 WL_206 WL_207 VSS VDD RA1SHD_2048x32M8FCR
XI1_212 WL_208 WL_209 VSS VDD RA1SHD_2048x32M8FCR
XI1_214 WL_210 WL_211 VSS VDD RA1SHD_2048x32M8FCR
XI1_216 WL_212 WL_213 VSS VDD RA1SHD_2048x32M8FCR
XI1_218 WL_214 WL_215 VSS VDD RA1SHD_2048x32M8FCR
XI1_22 WL_18 WL_19 VSS VDD RA1SHD_2048x32M8FCR
XI1_220 WL_216 WL_217 VSS VDD RA1SHD_2048x32M8FCR
XI1_222 WL_218 WL_219 VSS VDD RA1SHD_2048x32M8FCR
XI1_224 WL_220 WL_221 VSS VDD RA1SHD_2048x32M8FCR
XI1_226 WL_222 WL_223 VSS VDD RA1SHD_2048x32M8FCR
XI1_228 WL_224 WL_225 VSS VDD RA1SHD_2048x32M8FCR
XI1_230 WL_226 WL_227 VSS VDD RA1SHD_2048x32M8FCR
XI1_232 WL_228 WL_229 VSS VDD RA1SHD_2048x32M8FCR
XI1_234 WL_230 WL_231 VSS VDD RA1SHD_2048x32M8FCR
XI1_236 WL_232 WL_233 VSS VDD RA1SHD_2048x32M8FCR
XI1_238 WL_234 WL_235 VSS VDD RA1SHD_2048x32M8FCR
XI1_24 WL_20 WL_21 VSS VDD RA1SHD_2048x32M8FCR
XI1_240 WL_236 WL_237 VSS VDD RA1SHD_2048x32M8FCR
XI1_242 WL_238 WL_239 VSS VDD RA1SHD_2048x32M8FCR
XI1_244 WL_240 WL_241 VSS VDD RA1SHD_2048x32M8FCR
XI1_246 WL_242 WL_243 VSS VDD RA1SHD_2048x32M8FCR
XI1_248 WL_244 WL_245 VSS VDD RA1SHD_2048x32M8FCR
XI1_250 WL_246 WL_247 VSS VDD RA1SHD_2048x32M8FCR
XI1_252 WL_248 WL_249 VSS VDD RA1SHD_2048x32M8FCR
XI1_254 WL_250 WL_251 VSS VDD RA1SHD_2048x32M8FCR
XI1_256 WL_252 WL_253 VSS VDD RA1SHD_2048x32M8FCR
XI1_258 WL_254 WL_255 VSS VDD RA1SHD_2048x32M8FCR
XI1_26 WL_22 WL_23 VSS VDD RA1SHD_2048x32M8FCR
XI1_260 VSS VDD RA1SHD_2048x32M8FCUR
XI1_28 WL_24 WL_25 VSS VDD RA1SHD_2048x32M8FCR
XI1_30 WL_26 WL_27 VSS VDD RA1SHD_2048x32M8FCR
XI1_32 WL_28 WL_29 VSS VDD RA1SHD_2048x32M8FCR
XI1_34 WL_30 WL_31 VSS VDD RA1SHD_2048x32M8FCR
XI1_36 WL_32 WL_33 VSS VDD RA1SHD_2048x32M8FCR
XI1_38 WL_34 WL_35 VSS VDD RA1SHD_2048x32M8FCR
XI1_4 WL_0 WL_1 VSS VDD RA1SHD_2048x32M8FCR
XI1_40 WL_36 WL_37 VSS VDD RA1SHD_2048x32M8FCR
XI1_42 WL_38 WL_39 VSS VDD RA1SHD_2048x32M8FCR
XI1_44 WL_40 WL_41 VSS VDD RA1SHD_2048x32M8FCR
XI1_46 WL_42 WL_43 VSS VDD RA1SHD_2048x32M8FCR
XI1_48 WL_44 WL_45 VSS VDD RA1SHD_2048x32M8FCR
XI1_50 WL_46 WL_47 VSS VDD RA1SHD_2048x32M8FCR
XI1_52 WL_48 WL_49 VSS VDD RA1SHD_2048x32M8FCR
XI1_54 WL_50 WL_51 VSS VDD RA1SHD_2048x32M8FCR
XI1_56 WL_52 WL_53 VSS VDD RA1SHD_2048x32M8FCR
XI1_58 WL_54 WL_55 VSS VDD RA1SHD_2048x32M8FCR
XI1_6 WL_2 WL_3 VSS VDD RA1SHD_2048x32M8FCR
XI1_60 WL_56 WL_57 VSS VDD RA1SHD_2048x32M8FCR
XI1_62 WL_58 WL_59 VSS VDD RA1SHD_2048x32M8FCR
XI1_64 WL_60 WL_61 VSS VDD RA1SHD_2048x32M8FCR
XI1_66 WL_62 WL_63 VSS VDD RA1SHD_2048x32M8FCR
XI1_68 WL_64 WL_65 VSS VDD RA1SHD_2048x32M8FCR
XI1_70 WL_66 WL_67 VSS VDD RA1SHD_2048x32M8FCR
XI1_72 WL_68 WL_69 VSS VDD RA1SHD_2048x32M8FCR
XI1_74 WL_70 WL_71 VSS VDD RA1SHD_2048x32M8FCR
XI1_76 WL_72 WL_73 VSS VDD RA1SHD_2048x32M8FCR
XI1_78 WL_74 WL_75 VSS VDD RA1SHD_2048x32M8FCR
XI1_8 WL_4 WL_5 VSS VDD RA1SHD_2048x32M8FCR
XI1_80 WL_76 WL_77 VSS VDD RA1SHD_2048x32M8FCR
XI1_82 WL_78 WL_79 VSS VDD RA1SHD_2048x32M8FCR
XI1_84 WL_80 WL_81 VSS VDD RA1SHD_2048x32M8FCR
XI1_86 WL_82 WL_83 VSS VDD RA1SHD_2048x32M8FCR
XI1_88 WL_84 WL_85 VSS VDD RA1SHD_2048x32M8FCR
XI1_90 WL_86 WL_87 VSS VDD RA1SHD_2048x32M8FCR
XI1_92 WL_88 WL_89 VSS VDD RA1SHD_2048x32M8FCR
XI1_94 WL_90 WL_91 VSS VDD RA1SHD_2048x32M8FCR
XI1_96 WL_92 WL_93 VSS VDD RA1SHD_2048x32M8FCR
XI1_98 WL_94 WL_95 VSS VDD RA1SHD_2048x32M8FCR
.ENDS RA1SHD_2048x32M8RIGHT_CAP
****
.SUBCKT RA1SHD_2048x32M8CCMBB MBL MBL_ TIEDOWN WL VSS VDD
** RA1SHD_2048x32M8CCMBB: 8 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m3 CORED_ CORED VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
m5 CORED CORED_ VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
m7 VSS WL N12 VSS N L=0.265U W=80N AD=38.4F PD=1.04U AS=38.4F PS=1.04U
m8 VSS WL N13 VSS N L=0.265U W=80N AD=38.4F PD=1.04U AS=38.4F PS=1.04U
.ENDS RA1SHD_2048x32M8CCMBB
****
.SUBCKT RA1SHD_2048x32M8CCMBT MBL MBL_ TIEDOWN WL VSS VDD
** RA1SHD_2048x32M8CCMBT: 8 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.265U W=0.22U AD=0.1056P PD=1.18U AS=0.1056P
+  PS=1.18U
m3 CORED_ CORED VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m4 CORED_ CORED VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
m5 CORED CORED_ VDD VDD P L=0.2U W=0.215U AD=0.1032P PD=1.175U AS=0.1032P
+  PS=1.175U
m6 CORED CORED_ VSS VSS N L=0.18U W=0.27U AD=0.1296P PD=1.23U AS=0.1296P
+  PS=1.23U
m7 VSS WL N12 VSS N L=0.265U W=80N AD=38.4F PD=1.04U AS=38.4F PS=1.04U
m8 VSS WL N13 VSS N L=0.265U W=80N AD=38.4F PD=1.04U AS=38.4F PS=1.04U
.ENDS RA1SHD_2048x32M8CCMBT
****
.SUBCKT RA1SHD_2048x32M8CCPDBB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD_2048x32M8CCPDBB: 8 flat devices **
M0 NET14 NET18 VSS VSS N W=0.27U L=0.18U M=1
M1 NET11 WL VSS VSS N W=80N L=0.265U M=1
M2 MBL_ MWL NET14 VSS N W=0.22U L=0.265U M=1
M3 NET18 MWL MBL VSS N W=0.22U L=0.265U M=1
M4 NET18 GTP VSS VSS N W=0.27U L=0.18U M=1
M5 VSS WL NET045 VSS N W=80N L=0.265U M=1
M6 VDD NET18 NET048 VDD P W=0.215U L=0.2U M=1
M7 VDD GTP NET051 VDD P W=0.215U L=0.2U M=1
.ENDS RA1SHD_2048x32M8CCPDBB
****
.SUBCKT RA1SHD_2048x32M8CCPDT GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD_2048x32M8CCPDT: 8 flat devices **
M0 NET36 GTP VDD VDD P W=0.215U L=0.2U M=1
M1 NET39 NET40 VDD VDD P W=0.215U L=0.2U M=1
M2 NET51 NET40 VSS VSS N W=0.27U L=0.18U M=1
M3 NET45 WL VSS VSS N W=80N L=0.265U M=1
M4 VSS WL NET47 VSS N W=80N L=0.265U M=1
M5 NET51 MWL MBL VSS N W=0.22U L=0.265U M=1
M6 MBL_ MWL NET40 VSS N W=0.22U L=0.265U M=1
M7 NET40 GTP VSS VSS N W=0.27U L=0.18U M=1
.ENDS RA1SHD_2048x32M8CCPDT
****
.SUBCKT RA1SHD_2048x32M8CCPDB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** RA1SHD_2048x32M8CCPDB: 9 flat devices **
D0 VDD VDD DN 0 0
M1 NET14 NET18 VSS VSS N W=0.27U L=0.18U M=1
M2 VSS WL NET8 VSS N W=80N L=0.265U M=1
M3 MBL_ MWL NET14 VSS N W=0.22U L=0.265U M=1
M4 NET18 MWL MBL VSS N W=0.22U L=0.265U M=1
M5 NET18 GTP VSS VSS N W=0.27U L=0.18U M=1
M6 NET12 WL VSS VSS N W=80N L=0.265U M=1
M7 VDD NET18 NET048 VDD P W=0.215U L=0.2U M=1
M8 VDD GTP NET051 VDD P W=0.215U L=0.2U M=1
.ENDS RA1SHD_2048x32M8CCPDB
****
.SUBCKT RA1SHD_2048x32M8MBLBASE GTP MBL MBL_ MWLD MWLS VSS VDD
** RA1SHD_2048x32M8MBLBASE: 19 flat devices **
D0 VDD VDD DP 0 0
M0 VDD GTP NET54 VDD P W=0.215U L=0.2U M=1
M1 NET58 GTP VDD VDD P W=0.215U L=0.2U M=1
M10 NET90 GTP VSS VSS N W=0.27U L=0.18U M=1
M11 VSS GTP NET87 VSS N W=0.27U L=0.18U M=1
M12 MBL MWLD NET90 VSS N W=0.22U L=0.265U M=1
M13 NET87 MWLD MBL VSS N W=0.22U L=0.265U M=1
M14 NET97 MWLD MBL VSS N W=0.22U L=0.265U M=1
M17 VSS GTP NET97 VSS N W=0.27U L=0.18U M=1
M2 VDD GTP NET60 VDD P W=0.215U L=0.2U M=1
M3 NET64 GTP VDD VDD P W=0.215U L=0.2U M=1
M4 VSS VSS VSS VSS N W=0.22U L=0.27U M=1
M5 VSS VSS VSS VSS N W=0.22U L=0.27U M=1
M8 NET79 MWLD MBL VSS N W=0.22U L=0.265U M=1
M9 VSS GTP NET79 VSS N W=0.27U L=0.18U M=1
MM1 NET5 MWLD VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM3 NET3 MWLS VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM4 NET4 MWLD VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
MM5 NET6 MWLS VSS VSS N AD=26F AS=70F L=0.265U PD=0.8U PS=1.9U W=80N
.ENDS RA1SHD_2048x32M8MBLBASE
****
.SUBCKT RA1SHD_2048x32M8MODEL_COL GTP MBL MBL_ MWLD MWLS WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130
+  WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140
+  WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150
+  WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160
+  WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170
+  WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180
+  WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190
+  WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200
+  WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210
+  WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220
+  WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230
+  WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240
+  WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250
+  WL_251 WL_252 WL_253 WL_254 WL_255 VSS VDD
** RA1SHD_2048x32M8MODEL_COL: 2089 flat devices **
XI0_1 MBL MBL_ VSS WL_0 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_10 MBL_ MBL VSS WL_9 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_100 MBL_ MBL VSS WL_99 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_101 MBL MBL_ VSS WL_100 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_102 MBL_ MBL VSS WL_101 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_103 MBL MBL_ VSS WL_102 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_104 MBL_ MBL VSS WL_103 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_105 MBL MBL_ VSS WL_104 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_106 MBL_ MBL VSS WL_105 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_107 MBL MBL_ VSS WL_106 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_108 MBL_ MBL VSS WL_107 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_109 MBL MBL_ VSS WL_108 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_11 MBL MBL_ VSS WL_10 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_110 MBL_ MBL VSS WL_109 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_111 MBL MBL_ VSS WL_110 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_112 MBL_ MBL VSS WL_111 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_113 MBL MBL_ VSS WL_112 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_114 MBL_ MBL VSS WL_113 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_115 MBL MBL_ VSS WL_114 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_116 MBL_ MBL VSS WL_115 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_117 MBL MBL_ VSS WL_116 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_118 MBL_ MBL VSS WL_117 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_119 MBL MBL_ VSS WL_118 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_12 MBL_ MBL VSS WL_11 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_120 MBL_ MBL VSS WL_119 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_121 MBL MBL_ VSS WL_120 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_122 MBL_ MBL VSS WL_121 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_123 MBL MBL_ VSS WL_122 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_124 MBL_ MBL VSS WL_123 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_125 MBL MBL_ VSS WL_124 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_126 MBL_ MBL VSS WL_125 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_127 MBL MBL_ VSS WL_126 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_128 MBL_ MBL VSS WL_127 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_129 MBL MBL_ VSS WL_128 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_13 MBL MBL_ VSS WL_12 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_130 MBL_ MBL VSS WL_129 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_131 MBL MBL_ VSS WL_130 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_132 MBL_ MBL VSS WL_131 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_133 MBL MBL_ VSS WL_132 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_134 MBL_ MBL VSS WL_133 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_135 MBL MBL_ VSS WL_134 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_136 MBL_ MBL VSS WL_135 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_137 MBL MBL_ VSS WL_136 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_138 MBL_ MBL VSS WL_137 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_139 MBL MBL_ VSS WL_138 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_14 MBL_ MBL VSS WL_13 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_140 MBL_ MBL VSS WL_139 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_141 MBL MBL_ VSS WL_140 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_142 MBL_ MBL VSS WL_141 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_143 MBL MBL_ VSS WL_142 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_144 MBL_ MBL VSS WL_143 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_145 MBL MBL_ VSS WL_144 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_146 MBL_ MBL VSS WL_145 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_147 MBL MBL_ VSS WL_146 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_148 MBL_ MBL VSS WL_147 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_149 MBL MBL_ VSS WL_148 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_15 MBL MBL_ VSS WL_14 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_150 MBL_ MBL VSS WL_149 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_151 MBL MBL_ VSS WL_150 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_152 MBL_ MBL VSS WL_151 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_153 MBL MBL_ VSS WL_152 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_154 MBL_ MBL VSS WL_153 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_155 MBL MBL_ VSS WL_154 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_156 MBL_ MBL VSS WL_155 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_157 MBL MBL_ VSS WL_156 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_158 MBL_ MBL VSS WL_157 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_159 MBL MBL_ VSS WL_158 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_16 MBL_ MBL VSS WL_15 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_160 MBL_ MBL VSS WL_159 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_161 MBL MBL_ VSS WL_160 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_162 MBL_ MBL VSS WL_161 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_163 MBL MBL_ VSS WL_162 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_164 MBL_ MBL VSS WL_163 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_165 MBL MBL_ VSS WL_164 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_166 MBL_ MBL VSS WL_165 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_167 MBL MBL_ VSS WL_166 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_168 MBL_ MBL VSS WL_167 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_169 MBL MBL_ VSS WL_168 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_17 MBL MBL_ VSS WL_16 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_170 MBL_ MBL VSS WL_169 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_171 MBL MBL_ VSS WL_170 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_172 MBL_ MBL VSS WL_171 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_173 MBL MBL_ VSS WL_172 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_174 MBL_ MBL VSS WL_173 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_175 MBL MBL_ VSS WL_174 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_176 MBL_ MBL VSS WL_175 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_177 MBL MBL_ VSS WL_176 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_178 MBL_ MBL VSS WL_177 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_179 MBL MBL_ VSS WL_178 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_18 MBL_ MBL VSS WL_17 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_180 MBL_ MBL VSS WL_179 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_181 MBL MBL_ VSS WL_180 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_182 MBL_ MBL VSS WL_181 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_183 MBL MBL_ VSS WL_182 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_184 MBL_ MBL VSS WL_183 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_185 MBL MBL_ VSS WL_184 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_186 MBL_ MBL VSS WL_185 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_187 MBL MBL_ VSS WL_186 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_188 MBL_ MBL VSS WL_187 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_189 MBL MBL_ VSS WL_188 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_19 MBL MBL_ VSS WL_18 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_190 MBL_ MBL VSS WL_189 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_191 MBL MBL_ VSS WL_190 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_192 MBL_ MBL VSS WL_191 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_193 MBL MBL_ VSS WL_192 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_194 MBL_ MBL VSS WL_193 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_195 MBL MBL_ VSS WL_194 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_196 MBL_ MBL VSS WL_195 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_197 MBL MBL_ VSS WL_196 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_198 MBL_ MBL VSS WL_197 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_199 MBL MBL_ VSS WL_198 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_2 MBL_ MBL VSS WL_1 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_20 MBL_ MBL VSS WL_19 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_200 MBL_ MBL VSS WL_199 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_201 MBL MBL_ VSS WL_200 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_202 MBL_ MBL VSS WL_201 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_203 MBL MBL_ VSS WL_202 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_204 MBL_ MBL VSS WL_203 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_205 MBL MBL_ VSS WL_204 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_206 MBL_ MBL VSS WL_205 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_207 MBL MBL_ VSS WL_206 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_208 MBL_ MBL VSS WL_207 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_209 MBL MBL_ VSS WL_208 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_21 MBL MBL_ VSS WL_20 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_210 MBL_ MBL VSS WL_209 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_211 GTP MBL MBL_ MWLD VSS WL_210 VSS VDD RA1SHD_2048x32M8CCPDBB
XI0_212 GTP MBL_ MBL MWLD VSS WL_211 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_213 GTP MBL MBL_ MWLD VSS WL_212 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_214 GTP MBL_ MBL MWLD VSS WL_213 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_215 GTP MBL MBL_ MWLD VSS WL_214 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_216 GTP MBL_ MBL MWLD VSS WL_215 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_217 GTP MBL MBL_ MWLD VSS WL_216 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_218 GTP MBL_ MBL MWLD VSS WL_217 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_219 GTP MBL MBL_ MWLD VSS WL_218 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_22 MBL_ MBL VSS WL_21 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_220 GTP MBL_ MBL MWLD VSS WL_219 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_221 GTP MBL MBL_ MWLD VSS WL_220 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_222 GTP MBL_ MBL MWLD VSS WL_221 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_223 GTP MBL MBL_ MWLD VSS WL_222 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_224 GTP MBL_ MBL MWLD VSS WL_223 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_225 GTP MBL MBL_ MWLD VSS WL_224 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_226 GTP MBL_ MBL MWLD VSS WL_225 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_227 GTP MBL MBL_ MWLD VSS WL_226 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_228 GTP MBL_ MBL MWLD VSS WL_227 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_229 GTP MBL MBL_ MWLD VSS WL_228 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_23 MBL MBL_ VSS WL_22 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_230 GTP MBL_ MBL MWLD VSS WL_229 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_231 GTP MBL MBL_ MWLD VSS WL_230 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_232 GTP MBL_ MBL MWLD VSS WL_231 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_233 GTP MBL MBL_ MWLD VSS WL_232 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_234 GTP MBL_ MBL MWLD VSS WL_233 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_235 GTP MBL MBL_ MWLD VSS WL_234 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_236 GTP MBL_ MBL MWLD VSS WL_235 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_237 GTP MBL MBL_ MWLD VSS WL_236 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_238 GTP MBL_ MBL MWLD VSS WL_237 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_239 GTP MBL MBL_ MWLD VSS WL_238 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_24 MBL_ MBL VSS WL_23 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_240 GTP MBL_ MBL MWLD VSS WL_239 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_241 GTP MBL MBL_ MWLD VSS WL_240 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_242 GTP MBL_ MBL MWLD VSS WL_241 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_243 GTP MBL MBL_ MWLD VSS WL_242 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_244 GTP MBL_ MBL MWLD VSS WL_243 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_245 GTP MBL MBL_ MWLD VSS WL_244 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_246 GTP MBL_ MBL MWLD VSS WL_245 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_247 GTP MBL MBL_ MWLD VSS WL_246 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_248 GTP MBL_ MBL MWLD VSS WL_247 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_249 GTP MBL MBL_ MWLD VSS WL_248 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_25 MBL MBL_ VSS WL_24 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_250 GTP MBL_ MBL MWLD VSS WL_249 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_251 GTP MBL MBL_ MWLD VSS WL_250 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_252 GTP MBL_ MBL MWLD VSS WL_251 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_253 GTP MBL MBL_ MWLD VSS WL_252 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_254 GTP MBL_ MBL MWLD VSS WL_253 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_255 GTP MBL MBL_ MWLD VSS WL_254 VSS VDD RA1SHD_2048x32M8CCPDB
XI0_256 GTP MBL_ MBL MWLD VSS WL_255 VSS VDD RA1SHD_2048x32M8CCPDT
XI0_257 GTP MBL MBL_ MWLD MWLS VSS VDD RA1SHD_2048x32M8MBLBASE
XI0_26 MBL_ MBL VSS WL_25 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_27 MBL MBL_ VSS WL_26 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_28 MBL_ MBL VSS WL_27 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_29 MBL MBL_ VSS WL_28 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_3 MBL MBL_ VSS WL_2 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_30 MBL_ MBL VSS WL_29 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_31 MBL MBL_ VSS WL_30 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_32 MBL_ MBL VSS WL_31 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_33 MBL MBL_ VSS WL_32 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_34 MBL_ MBL VSS WL_33 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_35 MBL MBL_ VSS WL_34 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_36 MBL_ MBL VSS WL_35 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_37 MBL MBL_ VSS WL_36 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_38 MBL_ MBL VSS WL_37 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_39 MBL MBL_ VSS WL_38 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_4 MBL_ MBL VSS WL_3 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_40 MBL_ MBL VSS WL_39 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_41 MBL MBL_ VSS WL_40 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_42 MBL_ MBL VSS WL_41 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_43 MBL MBL_ VSS WL_42 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_44 MBL_ MBL VSS WL_43 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_45 MBL MBL_ VSS WL_44 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_46 MBL_ MBL VSS WL_45 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_47 MBL MBL_ VSS WL_46 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_48 MBL_ MBL VSS WL_47 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_49 MBL MBL_ VSS WL_48 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_5 MBL MBL_ VSS WL_4 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_50 MBL_ MBL VSS WL_49 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_51 MBL MBL_ VSS WL_50 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_52 MBL_ MBL VSS WL_51 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_53 MBL MBL_ VSS WL_52 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_54 MBL_ MBL VSS WL_53 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_55 MBL MBL_ VSS WL_54 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_56 MBL_ MBL VSS WL_55 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_57 MBL MBL_ VSS WL_56 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_58 MBL_ MBL VSS WL_57 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_59 MBL MBL_ VSS WL_58 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_6 MBL_ MBL VSS WL_5 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_60 MBL_ MBL VSS WL_59 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_61 MBL MBL_ VSS WL_60 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_62 MBL_ MBL VSS WL_61 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_63 MBL MBL_ VSS WL_62 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_64 MBL_ MBL VSS WL_63 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_65 MBL MBL_ VSS WL_64 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_66 MBL_ MBL VSS WL_65 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_67 MBL MBL_ VSS WL_66 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_68 MBL_ MBL VSS WL_67 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_69 MBL MBL_ VSS WL_68 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_7 MBL MBL_ VSS WL_6 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_70 MBL_ MBL VSS WL_69 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_71 MBL MBL_ VSS WL_70 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_72 MBL_ MBL VSS WL_71 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_73 MBL MBL_ VSS WL_72 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_74 MBL_ MBL VSS WL_73 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_75 MBL MBL_ VSS WL_74 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_76 MBL_ MBL VSS WL_75 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_77 MBL MBL_ VSS WL_76 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_78 MBL_ MBL VSS WL_77 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_79 MBL MBL_ VSS WL_78 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_8 MBL_ MBL VSS WL_7 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_80 MBL_ MBL VSS WL_79 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_81 MBL MBL_ VSS WL_80 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_82 MBL_ MBL VSS WL_81 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_83 MBL MBL_ VSS WL_82 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_84 MBL_ MBL VSS WL_83 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_85 MBL MBL_ VSS WL_84 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_86 MBL_ MBL VSS WL_85 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_87 MBL MBL_ VSS WL_86 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_88 MBL_ MBL VSS WL_87 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_89 MBL MBL_ VSS WL_88 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_9 MBL MBL_ VSS WL_8 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_90 MBL_ MBL VSS WL_89 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_91 MBL MBL_ VSS WL_90 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_92 MBL_ MBL VSS WL_91 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_93 MBL MBL_ VSS WL_92 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_94 MBL_ MBL VSS WL_93 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_95 MBL MBL_ VSS WL_94 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_96 MBL_ MBL VSS WL_95 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_97 MBL MBL_ VSS WL_96 VSS VDD RA1SHD_2048x32M8CCMBB
XI0_98 MBL_ MBL VSS WL_97 VSS VDD RA1SHD_2048x32M8CCMBT
XI0_99 MBL MBL_ VSS WL_98 VSS VDD RA1SHD_2048x32M8CCMBB
.ENDS RA1SHD_2048x32M8MODEL_COL
****
.SUBCKT RA1SHD_2048x32M8 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9]
+  A[10] CEN CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11]
+  D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23]
+  D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] OEN Q[0] Q[1] Q[2] Q[3]
+  Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16]
+  Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28]
+  Q[29] Q[30] Q[31] WEN[0] WEN[1] WEN[2] WEN[3] VSS VDD
** RA1SHD_2048x32M8: 419635 flat devices **
XI0_0 A0 A0_ DR DR_ DW DW_ GTP_2 GTP_2 GTP_2 OE_ VSS WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SHD_2048x32M8LEFT_CAP
XI1_0 A0 A0_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23
+  BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35
+  BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47
+  BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59
+  BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71
+  BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83
+  BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95
+  BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106
+  BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116
+  BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126
+  BL_127 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127
+  WEN[1] WEN[0] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5]
+  D[4] D[3] D[2] D[1] D[0] GTP_2 GTP_2 GTP_2 OE_ Q[15] Q[14] Q[13] Q[12]
+  Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] DR VSS DR_
+  VSS DW VSS DW_ VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0
+  YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8WING_16_LEFT
XI1_5 BL__64 BL_64 BL__65 BL_65 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6
+  BL__7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29
+  BL_30 BL_31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL_40
+  BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL__48 BL__49 BL__50 BL__51
+  BL__52 BL__53 BL__54 BL__55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63
+  BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BL_72 BL_73 BL_74 BL_75 BL_76
+  BL_77 BL_78 BL_79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87
+  BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL__96 BL__97 BL__98 BL__99
+  BL__100 BL__101 BL__102 BL__103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109
+  BL_110 BL_111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127 BL_0 BL_1
+  BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL__24 BL__25
+  BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47
+  BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL__72
+  BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL_80 BL_81 BL_82 BL_83
+  BL_84 BL_85 BL_86 BL_87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94
+  BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL_112 BL_113 BL_114 BL_115
+  BL_116 BL_117 BL_118 BL_119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 MWLB VSS VDD RA1SHD_2048x32M8MODEL_ROW_16
XI2_0 AGTPT AGTPT A0 A0_ GTP_2 MWLB MWLB OE_ VSS WL_0 WL_3 WL_4 WL_7 WL_8
+  WL_11 WL_12 WL_15 WL_16 WL_19 WL_20 WL_23 WL_24 WL_27 WL_28 WL_31 WL_32
+  WL_35 WL_36 WL_39 WL_40 WL_43 WL_44 WL_47 WL_48 WL_51 WL_52 WL_55 WL_56
+  WL_59 WL_60 WL_63 WL_64 WL_67 WL_68 WL_71 WL_72 WL_75 WL_76 WL_79 WL_80
+  WL_83 WL_84 WL_87 WL_88 WL_91 WL_92 WL_95 WL_96 WL_99 WL_100 WL_103 WL_104
+  WL_107 WL_108 WL_111 WL_112 WL_115 WL_116 WL_119 WL_120 WL_123 WL_124
+  WL_127 WL_128 WL_131 WL_132 WL_135 WL_136 WL_139 WL_140 WL_143 WL_144
+  WL_147 WL_148 WL_151 WL_152 WL_155 WL_156 WL_159 WL_160 WL_163 WL_164
+  WL_167 WL_168 WL_171 WL_172 WL_175 WL_176 WL_179 WL_180 WL_183 WL_184
+  WL_187 WL_188 WL_191 WL_192 WL_195 WL_196 WL_199 WL_200 WL_203 WL_204
+  WL_207 WL_208 WL_211 WL_212 WL_215 WL_216 WL_219 WL_220 WL_223 WL_224
+  WL_227 WL_228 WL_231 WL_232 WL_235 WL_236 WL_239 WL_240 WL_243 WL_244
+  WL_247 WL_248 WL_251 WL_252 WL_255 WL_1 WL_2 WL_5 WL_6 WL_9 WL_10 WL_13
+  WL_14 WL_17 WL_18 WL_21 WL_22 WL_25 WL_26 WL_29 WL_30 WL_33 WL_34 WL_37
+  WL_38 WL_41 WL_42 WL_45 WL_46 WL_49 WL_50 WL_53 WL_54 WL_57 WL_58 WL_61
+  WL_62 WL_65 WL_66 WL_69 WL_70 WL_73 WL_74 WL_77 WL_78 WL_81 WL_82 WL_85
+  WL_86 WL_89 WL_90 WL_93 WL_94 WL_97 WL_98 WL_101 WL_102 WL_105 WL_106
+  WL_109 WL_110 WL_113 WL_114 WL_117 WL_118 WL_121 WL_122 WL_125 WL_126
+  WL_129 WL_130 WL_133 WL_134 WL_137 WL_138 WL_141 WL_142 WL_145 WL_146
+  WL_149 WL_150 WL_153 WL_154 WL_157 WL_158 WL_161 WL_162 WL_165 WL_166
+  WL_169 WL_170 WL_173 WL_174 WL_177 WL_178 WL_181 WL_182 WL_185 WL_186
+  WL_189 WL_190 WL_193 WL_194 WL_197 WL_198 WL_201 WL_202 WL_205 WL_206
+  WL_209 WL_210 WL_213 WL_214 WL_217 WL_218 WL_221 WL_222 WL_225 WL_226
+  WL_229 WL_230 WL_233 WL_234 WL_237 WL_238 WL_241 WL_242 WL_245 WL_246
+  WL_249 WL_250 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SHD_2048x32M8ADDR_CAP2
XI3_0 A[9] A[6] A[3] A[10] A[7] A[4] A[8] A[5] AGTPT AGTPT A0 A0_ VSS OE_ VSS
+  XP_0_0 XP_0_1 XP_0_2 XP_1_0 XP_1_1 XP_1_2 XP_2_0 XP_2_1 XP_2_2 XP_3_0
+  XP_3_1 XP_3_2 XP_4_0 XP_4_1 XP_5_0 XP_5_1 XP_6_0 XP_6_1 XP_7_0 XP_7_1 YP0_0
+  YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8X_PRE_DECODE
XI3_3 GTP_2 MBL MBL_ MWLB WL_0 WL_3 WL_4 WL_7 WL_8 WL_11 WL_12 WL_15 WL_16
+  WL_19 WL_20 WL_23 WL_24 WL_27 WL_28 WL_31 WL_32 WL_35 WL_36 WL_39 WL_40
+  WL_43 WL_44 WL_47 WL_48 WL_51 WL_52 WL_55 WL_56 WL_59 WL_60 WL_63 WL_64
+  WL_67 WL_68 WL_71 WL_72 WL_75 WL_76 WL_79 WL_80 WL_83 WL_84 WL_87 WL_88
+  WL_91 WL_92 WL_95 WL_96 WL_99 WL_100 WL_103 WL_104 WL_107 WL_108 WL_111
+  WL_112 WL_115 WL_116 WL_119 WL_120 WL_123 WL_124 WL_127 WL_128 WL_131
+  WL_132 WL_135 WL_136 WL_139 WL_140 WL_143 WL_144 WL_147 WL_148 WL_151
+  WL_152 WL_155 WL_156 WL_159 WL_160 WL_163 WL_164 WL_167 WL_168 WL_171
+  WL_172 WL_175 WL_176 WL_179 WL_180 WL_183 WL_184 WL_187 WL_188 WL_191
+  WL_192 WL_195 WL_196 WL_199 WL_200 WL_203 WL_204 WL_207 WL_208 WL_211
+  WL_212 WL_215 WL_216 WL_219 WL_220 WL_223 WL_224 WL_227 WL_228 WL_231
+  WL_232 WL_235 WL_236 WL_239 WL_240 WL_243 WL_244 WL_247 WL_248 WL_251
+  WL_252 WL_255 WL_1 WL_2 WL_5 WL_6 WL_9 WL_10 WL_13 WL_14 WL_17 WL_18 WL_21
+  WL_22 WL_25 WL_26 WL_29 WL_30 WL_33 WL_34 WL_37 WL_38 WL_41 WL_42 WL_45
+  WL_46 WL_49 WL_50 WL_53 WL_54 WL_57 WL_58 WL_61 WL_62 WL_65 WL_66 WL_69
+  WL_70 WL_73 WL_74 WL_77 WL_78 WL_81 WL_82 WL_85 WL_86 WL_89 WL_90 WL_93
+  WL_94 WL_97 WL_98 WL_101 WL_102 WL_105 WL_106 WL_109 WL_110 WL_113 WL_114
+  WL_117 WL_118 WL_121 WL_122 WL_125 WL_126 WL_129 WL_130 WL_133 WL_134
+  WL_137 WL_138 WL_141 WL_142 WL_145 WL_146 WL_149 WL_150 WL_153 WL_154
+  WL_157 WL_158 WL_161 WL_162 WL_165 WL_166 WL_169 WL_170 WL_173 WL_174
+  WL_177 WL_178 WL_181 WL_182 WL_185 WL_186 WL_189 WL_190 WL_193 WL_194
+  WL_197 WL_198 WL_201 WL_202 WL_205 WL_206 WL_209 WL_210 WL_213 WL_214
+  WL_217 WL_218 WL_221 WL_222 WL_225 WL_226 WL_229 WL_230 WL_233 WL_234
+  WL_237 WL_238 WL_241 WL_242 WL_245 WL_246 WL_249 WL_250 WL_253 WL_254
+  XP_2_0 XP_0_0 XP_6_0 XP_4_0 XP_2_1 XP_0_1 XP_3_0 XP_1_0 XP_7_0 XP_5_0
+  XP_3_1 XP_1_1 XP_0_2 XP_1_2 XP_2_2 XP_3_2 XP_4_1 XP_5_1 XP_6_1 XP_7_1 VSS
+  VDD RA1SHD_2048x32M8WORD_ROWS
XI4_0 A[1] A[0] A[2] AGTPT A0 A0_ VSS CLK GSRCN GTPN OE_ RST VSS YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD RA1SHD_2048x32M8Y_DECODE
XI5_0 CEN CEN_ CLK GSRCN GTP_2 GTPN MBL OE_ OEN OEN_ RST VSS WE VSS WEN_ VSS
+  VDD RA1SHD_2048x32M8HBFX
XI5_2 A0 A0_ AGTPT CLK GSRCN GTPN GTP_2 GTP_2 GTP_2 GTP_2 RST YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8CLK_DRVS
XI6_2 A0 A0_ CLK GSRCN GTP_2 GTPN MBL MBL_ RST YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS
+  VSS VSS VSS VDD RA1SHD_2048x32M8FLCIO
XI6_4 GTP_2 MBL MBL_ MWLB MWLB WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 VSS VDD RA1SHD_2048x32M8MODEL_COL
XI7_0 A0 A0_ BL_0_1063 BL_1_1059 BL_2_1055 BL_3_1051 BL_4_1047 BL_5_1043
+  BL_6_1039 BL_7_1035 BL_8_1033 BL_9_1029 BL_10_1025 BL_11_1021 BL_12_1017
+  BL_13_1013 BL_14_1009 BL_15_1005 BL_16_999 BL_17_995 BL_18_991 BL_19_987
+  BL_20_983 BL_21_979 BL_22_975 BL_23_971 BL_24_969 BL_25_965 BL_26_961
+  BL_27_957 BL_28_953 BL_29_949 BL_30_945 BL_31_941 BL_32_935 BL_33_931
+  BL_34_927 BL_35_923 BL_36_919 BL_37_915 BL_38_911 BL_39_907 BL_40_905
+  BL_41_901 BL_42_897 BL_43_893 BL_44_889 BL_45_885 BL_46_881 BL_47_877
+  BL_48_871 BL_49_867 BL_50_863 BL_51_859 BL_52_855 BL_53_851 BL_54_847
+  BL_55_843 BL_56_841 BL_57_837 BL_58_833 BL_59_829 BL_60_825 BL_61_821
+  BL_62_817 BL_63_813 BL_64_807 BL_65_803 BL_66_799 BL_67_795 BL_68_791
+  BL_69_787 BL_70_783 BL_71_779 BL_72_777 BL_73_773 BL_74_769 BL_75_765
+  BL_76_761 BL_77_757 BL_78_753 BL_79_749 BL_80_743 BL_81_739 BL_82_735
+  BL_83_731 BL_84_727 BL_85_723 BL_86_719 BL_87_715 BL_88_713 BL_89_709
+  BL_90_705 BL_91_701 BL_92_697 BL_93_693 BL_94_689 BL_95_685 BL_96_679
+  BL_97_675 BL_98_671 BL_99_667 BL_100_663 BL_101_659 BL_102_655 BL_103_651
+  BL_104_649 BL_105_645 BL_106_641 BL_107_637 BL_108_633 BL_109_629
+  BL_110_625 BL_111_621 BL_112_615 BL_113_611 BL_114_607 BL_115_603
+  BL_116_599 BL_117_595 BL_118_591 BL_119_587 BL_120_585 BL_121_581
+  BL_122_577 BL_123_573 BL_124_569 BL_125_565 BL_126_561 BL_127_557
+  BL__0_1065 BL__1_1061 BL__2_1057 BL__3_1053 BL__4_1049 BL__5_1045
+  BL__6_1041 BL__7_1037 BL__8_1031 BL__9_1027 BL__10_1023 BL__11_1019
+  BL__12_1015 BL__13_1011 BL__14_1007 BL__15_1003 BL__16_1001 BL__17_997
+  BL__18_993 BL__19_989 BL__20_985 BL__21_981 BL__22_977 BL__23_973
+  BL__24_967 BL__25_963 BL__26_959 BL__27_955 BL__28_951 BL__29_947
+  BL__30_943 BL__31_939 BL__32_937 BL__33_933 BL__34_929 BL__35_925
+  BL__36_921 BL__37_917 BL__38_913 BL__39_909 BL__40_903 BL__41_899
+  BL__42_895 BL__43_891 BL__44_887 BL__45_883 BL__46_879 BL__47_875
+  BL__48_873 BL__49_869 BL__50_865 BL__51_861 BL__52_857 BL__53_853
+  BL__54_849 BL__55_845 BL__56_839 BL__57_835 BL__58_831 BL__59_827
+  BL__60_823 BL__61_819 BL__62_815 BL__63_811 BL__64_809 BL__65_805
+  BL__66_801 BL__67_797 BL__68_793 BL__69_789 BL__70_785 BL__71_781
+  BL__72_775 BL__73_771 BL__74_767 BL__75_763 BL__76_759 BL__77_755
+  BL__78_751 BL__79_747 BL__80_745 BL__81_741 BL__82_737 BL__83_733
+  BL__84_729 BL__85_725 BL__86_721 BL__87_717 BL__88_711 BL__89_707
+  BL__90_703 BL__91_699 BL__92_695 BL__93_691 BL__94_687 BL__95_683
+  BL__96_681 BL__97_677 BL__98_673 BL__99_669 BL__100_665 BL__101_661
+  BL__102_657 BL__103_653 BL__104_647 BL__105_643 BL__106_639 BL__107_635
+  BL__108_631 BL__109_627 BL__110_623 BL__111_619 BL__112_617 BL__113_613
+  BL__114_609 BL__115_605 BL__116_601 BL__117_597 BL__118_593 BL__119_589
+  BL__120_583 BL__121_579 BL__122_575 BL__123_571 BL__124_567 BL__125_563
+  BL__126_559 BL__127_555 WEN[2] WEN[3] D[16] D[17] D[18] D[19] D[20] D[21]
+  D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] GTP_2 GTP_2
+  GTP_2 OE_ Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26]
+  Q[27] Q[28] Q[29] Q[30] Q[31] VSS STUBDR_1 VSS STUBDR__1 VSS STUBDW_1 VSS
+  STUBDW__1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SHD_2048x32M8WING_16_RIGHT
XI7_5 BL__64_809 BL_64_807 BL__65_805 BL_65_803 BL__0_1065 BL__1_1061
+  BL__2_1057 BL__3_1053 BL__4_1049 BL__5_1045 BL__6_1041 BL__7_1037 BL_8_1033
+  BL_9_1029 BL_10_1025 BL_11_1021 BL_12_1017 BL_13_1013 BL_14_1009 BL_15_1005
+  BL__16_1001 BL__17_997 BL__18_993 BL__19_989 BL__20_985 BL__21_981
+  BL__22_977 BL__23_973 BL_24_969 BL_25_965 BL_26_961 BL_27_957 BL_28_953
+  BL_29_949 BL_30_945 BL_31_941 BL__32_937 BL__33_933 BL__34_929 BL__35_925
+  BL__36_921 BL__37_917 BL__38_913 BL__39_909 BL_40_905 BL_41_901 BL_42_897
+  BL_43_893 BL_44_889 BL_45_885 BL_46_881 BL_47_877 BL__48_873 BL__49_869
+  BL__50_865 BL__51_861 BL__52_857 BL__53_853 BL__54_849 BL__55_845 BL_56_841
+  BL_57_837 BL_58_833 BL_59_829 BL_60_825 BL_61_821 BL_62_817 BL_63_813
+  BL__66_801 BL__67_797 BL__68_793 BL__69_789 BL__70_785 BL__71_781 BL_72_777
+  BL_73_773 BL_74_769 BL_75_765 BL_76_761 BL_77_757 BL_78_753 BL_79_749
+  BL__80_745 BL__81_741 BL__82_737 BL__83_733 BL__84_729 BL__85_725
+  BL__86_721 BL__87_717 BL_88_713 BL_89_709 BL_90_705 BL_91_701 BL_92_697
+  BL_93_693 BL_94_689 BL_95_685 BL__96_681 BL__97_677 BL__98_673 BL__99_669
+  BL__100_665 BL__101_661 BL__102_657 BL__103_653 BL_104_649 BL_105_645
+  BL_106_641 BL_107_637 BL_108_633 BL_109_629 BL_110_625 BL_111_621
+  BL__112_617 BL__113_613 BL__114_609 BL__115_605 BL__116_601 BL__117_597
+  BL__118_593 BL__119_589 BL_120_585 BL_121_581 BL_122_577 BL_123_573
+  BL_124_569 BL_125_565 BL_126_561 BL_127_557 BL_0_1063 BL_1_1059 BL_2_1055
+  BL_3_1051 BL_4_1047 BL_5_1043 BL_6_1039 BL_7_1035 BL__8_1031 BL__9_1027
+  BL__10_1023 BL__11_1019 BL__12_1015 BL__13_1011 BL__14_1007 BL__15_1003
+  BL_16_999 BL_17_995 BL_18_991 BL_19_987 BL_20_983 BL_21_979 BL_22_975
+  BL_23_971 BL__24_967 BL__25_963 BL__26_959 BL__27_955 BL__28_951 BL__29_947
+  BL__30_943 BL__31_939 BL_32_935 BL_33_931 BL_34_927 BL_35_923 BL_36_919
+  BL_37_915 BL_38_911 BL_39_907 BL__40_903 BL__41_899 BL__42_895 BL__43_891
+  BL__44_887 BL__45_883 BL__46_879 BL__47_875 BL_48_871 BL_49_867 BL_50_863
+  BL_51_859 BL_52_855 BL_53_851 BL_54_847 BL_55_843 BL__56_839 BL__57_835
+  BL__58_831 BL__59_827 BL__60_823 BL__61_819 BL__62_815 BL__63_811 BL_66_799
+  BL_67_795 BL_68_791 BL_69_787 BL_70_783 BL_71_779 BL__72_775 BL__73_771
+  BL__74_767 BL__75_763 BL__76_759 BL__77_755 BL__78_751 BL__79_747 BL_80_743
+  BL_81_739 BL_82_735 BL_83_731 BL_84_727 BL_85_723 BL_86_719 BL_87_715
+  BL__88_711 BL__89_707 BL__90_703 BL__91_699 BL__92_695 BL__93_691
+  BL__94_687 BL__95_683 BL_96_679 BL_97_675 BL_98_671 BL_99_667 BL_100_663
+  BL_101_659 BL_102_655 BL_103_651 BL__104_647 BL__105_643 BL__106_639
+  BL__107_635 BL__108_631 BL__109_627 BL__110_623 BL__111_619 BL_112_615
+  BL_113_611 BL_114_607 BL_115_603 BL_116_599 BL_117_595 BL_118_591
+  BL_119_587 BL__120_583 BL__121_579 BL__122_575 BL__123_571 BL__124_567
+  BL__125_563 BL__126_559 BL__127_555 MWLB VSS VDD
+  RA1SHD_2048x32M8MODEL_ROW_16
XI8_0 A0 A0_ GTP_2 GTP_2 GTP_2 OE_ VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SHD_2048x32M8RIGHT_CAP
.ENDS RA1SHD_2048x32M8
